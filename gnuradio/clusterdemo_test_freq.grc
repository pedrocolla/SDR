options:
  parameters:
    author: pi
    generate_options: qt_gui
    id: clusterdemo_test_freq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: customModule_filtro_FIR_3polos_cpp_0
  id: customModule_filtro_FIR_3polos_cpp
  parameters:
    coef0: '0.05964532'
    coef1: '0.06'
    coef2: '0.05964532'
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [-0.000825921231325207655556142061215041394,-0.003169594663766307513635966941478727676,
      -0.007490150022454497569235343235050095245,-0.011392924569276900378933525814773020102,
      -0.007615797939547183648123507282434729859, 0.012597298745315127152522016729108145228,
       0.053172321589381205120261597585340496153, 0.108108486129147918219928214966785162687,
       0.161690634955576062470328224662807770073, 0.19492564700694975377004425354243721813, 
       0.19492564700694975377004425354243721813, 0.161690634955576062470328224662807770073,
       0.108108486129147918219928214966785162687, 0.053172321589381205120261597585340496153,
       0.012597298745315127152522016729108145228,-0.007615797939547183648123507282434729859,
      -0.011392924569276900378933525814773020102,-0.007490150022454497569235343235050095245,
      -0.003169594663766307513635966941478727676,-0.000825921231325207655556142061215041394]
    comment: FIR Orden20 Hamming Fc=100Hz Fs=1000Hz
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0_0
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [0.000320362424863679048653991587869427349, 0.000915688554425526978278182532733353582,
       0.001341155551857150162939347204371642874, 0.001357384060576103052345176003257165576,
       0.000666165963759637880237107765424298123,-0.000862117563136244259743012907648562759,
      -0.002909565635107423057365005902852317377,-0.004593586007083634223380208538856095402,
      -0.004694108232963912705204556630178558407,-0.002239460389777802890726166040735733986,
       0.002768200372038926316414775286034455348, 0.008877467039827944758623168297617667122,
       0.013341250581891686555202625186211662367, 0.013047725154040623607443194487132132053,
       0.00600214675023739898523933433693855477, -0.007217539561210916526645675617146480363,
      -0.022747566874395785258000657336197036784,-0.034000358909073762070374158383856411092,
      -0.03355980660790060243758858860019245185, -0.015880872119793384283914505772372649517,
       0.020178608380384446818744947904633590952, 0.070044835874201474834599423502368154004,
       0.124021431045317792607463047716009896249, 0.169786028110178871530777655607380438596,
       0.19603653203684243133686493365530623123,  0.19603653203684243133686493365530623123, 
       0.169786028110178871530777655607380438596, 0.124021431045317792607463047716009896249,
       0.070044835874201474834599423502368154004, 0.020178608380384446818744947904633590952,
      -0.015880872119793384283914505772372649517,-0.03355980660790060243758858860019245185, 
      -0.034000358909073762070374158383856411092,-0.022747566874395785258000657336197036784,
      -0.007217539561210916526645675617146480363, 0.00600214675023739898523933433693855477, 
       0.013047725154040623607443194487132132053, 0.013341250581891686555202625186211662367,
       0.008877467039827944758623168297617667122, 0.002768200372038926316414775286034455348,
      -0.002239460389777802890726166040735733986,-0.004694108232963912705204556630178558407,
      -0.004593586007083634223380208538856095402,-0.002909565635107423057365005902852317377,
      -0.000862117563136244259743012907648562759, 0.000666165963759637880237107765424298123,
       0.001357384060576103052345176003257165576, 0.001341155551857150162939347204371642874,
       0.000915688554425526978278182532733353582, 0.000320362424863679048653991587869427349]
    comment: FIR Orden50 Hamming Fc=100Hz Fs=1000Hz
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0_1
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [-0.000159218610761937911200758488661222145,-0.000430359456204313154097790272700763126,
      -0.000561775254636760605110590294231087682,-0.000489840873230431607388002390734982328,
      -0.000205138660856850552549265898072405889, 0.000227954566336893634263469077261277107,
       0.000669705996889420770122602899476760285, 0.000935068105496070158151600271168035761,
       0.000857842323225355054411300770311754604, 0.000372230362247760087138215290281095804,
      -0.000422936841594838148356005902428478294,-0.001256902810726467792715177473894527793,
      -0.00176050993133213982619333926038507343, -0.001610306240851903242239373525990231428,
      -0.000693627791860814487019670782075309035, 0.000780061826223386878265131372245377861,
       0.002290297318945717225391334181949787308, 0.003166042258238703412803749515092022193,
       0.002856840920924310581879845827302233374, 0.001213957125391211403289681847184056096,
      -0.001347227131676383658775986162936533219,-0.003905453568825525013236132920724230644,
      -0.005334169728864465893913848759666507249,-0.004759486744479700381926789987119263969,
      -0.002001671381602028627899603208106782404, 0.002200731660298483900045640737630492367,
       0.006326767221708212186881414851313820691, 0.008578929085475365395874192131486779545,
       0.007608160734253766391277373770662961761, 0.003184140060691302911988209700666629942,
      -0.003488248846301648335016531987662347092,-0.010006147282870192505299655749695375562,
      -0.013558745771432336932327267220443900442,-0.012036247337045483454809335910340450937,
      -0.005051693199621982467706349240188501426, 0.005561634076910163329565683909549989039,
       0.016071942561815044658857232207083143294, 0.022002174947367152818555879889572679531,
       0.019799738563965139231948242581893282477, 0.008459138643643174942932105864201730583,
      -0.009529048607261803374712805236868007341,-0.028361213005418703381188549883518135175,
      -0.040333835684212157590700087439472554252,-0.03814868318690734644293982569251966197,
      -0.017415187253869975764208888335815572646, 0.021484629846216300036454427413445955608,
       0.072858429076204614394107750285911606625, 0.126785617373732201196290247935394290835,
       0.171588240707207573265691280539613217115, 0.196987399839038984650230190709407906979,
       0.196987399839038984650230190709407906979, 0.171588240707207573265691280539613217115,
       0.126785617373732201196290247935394290835, 0.072858429076204614394107750285911606625,
       0.021484629846216300036454427413445955608,0.017415187253869975764208888335815572646,
      -0.03814868318690734644293982569251966197,-0.040333835684212157590700087439472554252,
      -0.028361213005418703381188549883518135175,-0.009529048607261803374712805236868007341,
       0.008459138643643174942932105864201730583, 0.019799738563965139231948242581893282477,
       0.022002174947367152818555879889572679531, 0.016071942561815044658857232207083143294,
       0.005561634076910163329565683909549989039,-0.005051693199621982467706349240188501426,
      -0.012036247337045483454809335910340450937,-0.013558745771432336932327267220443900442,
      -0.010006147282870192505299655749695375562,-0.003488248846301648335016531987662347092, 0.003184140060691302911988209700666629942, 0.007608160734253766391277373770662961761,
       0.008578929085475365395874192131486779545, 0.006326767221708212186881414851313820691,
       0.002200731660298483900045640737630492367,-0.002001671381602028627899603208106782404,
      -0.004759486744479700381926789987119263969,-0.005334169728864465893913848759666507249,
      -0.003905453568825525013236132920724230644,-0.001347227131676383658775986162936533219,
       0.001213957125391211403289681847184056096, 0.002856840920924310581879845827302233374,
       0.003166042258238703412803749515092022193, 0.002290297318945717225391334181949787308,
       0.000780061826223386878265131372245377861,-0.000693627791860814487019670782075309035,
      -0.001610306240851903242239373525990231428,-0.00176050993133213982619333926038507343,
      -0.001256902810726467792715177473894527793,-0.000422936841594838148356005902428478294,
       0.000372230362247760087138215290281095804, 0.000857842323225355054411300770311754604,
       0.000935068105496070158151600271168035761, 0.000669705996889420770122602899476760285,
       0.000227954566336893634263469077261277107,-0.000205138660856850552549265898072405889,
      -0.000489840873230431607388002390734982328,-0.000561775254636760605110590294231087682,
      -0.000430359456204313154097790272700763126,-0.000159218610761937911200758488661222145]
    comment: FIR Orden100 Hamming Fc=100Hz Fs=1000Hz
  states: {}
- name: customModule_filtro_FIR_cpp_0_2
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [-0.005230107296619057773157113189199662884,-0.012931101513474829028949031339834618848,
       0.01705008032939041642817024069245235296, 0.163563548040774831004995348848751746118,
       0.337547580439928718298858711932552978396, 0.337547580439928718298858711932552978396,
       0.163563548040774831004995348848751746118, 0.01705008032939041642817024069245235296, 
      -0.012931101513474829028949031339834618848,-0.005230107296619057773157113189199662884]
    comment: FIR Orden10 Hamming Fc=8000Hz Fs=44,1kHz
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0_2_0
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [-0.002649625683986659048507750213730105315,-0.00102626916841334447742795088487355315, 
       0.005786026774656596351198434291518424288, 0.01277825509292213751466604776396707166, 
      -0.000353022399592585510788578240237711725,-0.03747830192258361226009810707182623446, 
      -0.049545607147856732255242206974799046293, 0.031297171753709024377698710850381758064,
       0.199005919118201618500663130362227093428, 0.342185453582943499561963562882738187909,
       0.342185453582943499561963562882738187909, 0.199005919118201618500663130362227093428,
       0.031297171753709024377698710850381758064,-0.049545607147856732255242206974799046293,
      -0.03747830192258361226009810707182623446, -0.000353022399592585510788578240237711725,
       0.01277825509292213751466604776396707166, 0.005786026774656596351198434291518424288,
      -0.00102626916841334447742795088487355315, -0.002649625683986659048507750213730105315]
    comment: FIR Orden20 Hamming Fc=8000Hz Fs=44,1kHz
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0_2_0_0
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [-0.000825921231325207655556142061215041394,-0.003169594663766307513635966941478727676,
      -0.007490150022454497569235343235050095245,-0.011392924569276900378933525814773020102,
      -0.007615797939547183648123507282434729859, 0.012597298745315127152522016729108145228,
       0.053172321589381205120261597585340496153, 0.108108486129147918219928214966785162687,
       0.161690634955576062470328224662807770073, 0.19492564700694975377004425354243721813, 
       0.19492564700694975377004425354243721813, 0.161690634955576062470328224662807770073,
       0.108108486129147918219928214966785162687, 0.053172321589381205120261597585340496153,
       0.012597298745315127152522016729108145228,-0.007615797939547183648123507282434729859,
      -0.011392924569276900378933525814773020102,-0.007490150022454497569235343235050095245,
      -0.003169594663766307513635966941478727676,-0.000825921231325207655556142061215041394]
    comment: FIR Orden20 Hamming Fc=1000Hz Fs=10kHz
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0_2_0_0_0
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [0.000320362424863679048653991587869427349, 0.000915688554425526978278182532733353582, 0.001341155551857150162939347204371642874, 0.001357384060576103052345176003257165576, 0.000666165963759637880237107765424298123,-0.000862117563136244259743012907648562759,-0.002909565635107423057365005902852317377,-0.004593586007083634223380208538856095402,
      -0.004694108232963912705204556630178558407,-0.002239460389777802890726166040735733986,
       0.002768200372038926316414775286034455348, 0.008877467039827944758623168297617667122,
       0.013341250581891686555202625186211662367, 0.013047725154040623607443194487132132053,
       0.00600214675023739898523933433693855477, -0.007217539561210916526645675617146480363,
      -0.022747566874395785258000657336197036784,-0.034000358909073762070374158383856411092,
      -0.03355980660790060243758858860019245185, -0.015880872119793384283914505772372649517,
       0.020178608380384446818744947904633590952, 0.070044835874201474834599423502368154004,
       0.124021431045317792607463047716009896249, 0.169786028110178871530777655607380438596,
       0.19603653203684243133686493365530623123,  0.19603653203684243133686493365530623123, 
       0.169786028110178871530777655607380438596, 0.124021431045317792607463047716009896249,
       0.070044835874201474834599423502368154004, 0.020178608380384446818744947904633590952,
      -0.015880872119793384283914505772372649517,-0.03355980660790060243758858860019245185, 
      -0.034000358909073762070374158383856411092,-0.022747566874395785258000657336197036784,
      -0.007217539561210916526645675617146480363, 0.00600214675023739898523933433693855477, 
       0.013047725154040623607443194487132132053, 0.013341250581891686555202625186211662367,
       0.008877467039827944758623168297617667122, 0.002768200372038926316414775286034455348,
      -0.002239460389777802890726166040735733986,-0.004694108232963912705204556630178558407,
      -0.004593586007083634223380208538856095402,-0.002909565635107423057365005902852317377,
      -0.000862117563136244259743012907648562759, 0.000666165963759637880237107765424298123,
       0.001357384060576103052345176003257165576, 0.001341155551857150162939347204371642874,
       0.000915688554425526978278182532733353582, 0.000320362424863679048653991587869427349]
    comment: FIR Orden50 Hamming Fc=1000Hz Fs=10kHz
  states: {state: disabled}
- name: customModule_filtro_FIR_cpp_0_2_0_0_1
  id: customModule_filtro_FIR_cpp
  parameters:
    coef: |-
      [-0.000159218610761937911200758488661222145,-0.000430359456204313154097790272700763126,
      -0.000561775254636760605110590294231087682,-0.000489840873230431607388002390734982328,
      -0.000205138660856850552549265898072405889, 0.000227954566336893634263469077261277107,
       0.000669705996889420770122602899476760285, 0.000935068105496070158151600271168035761,
       0.000857842323225355054411300770311754604, 0.000372230362247760087138215290281095804,
      -0.000422936841594838148356005902428478294,-0.001256902810726467792715177473894527793,
      -0.00176050993133213982619333926038507343,-0.001610306240851903242239373525990231428,
      -0.000693627791860814487019670782075309035, 0.000780061826223386878265131372245377861,
       0.002290297318945717225391334181949787308, 0.003166042258238703412803749515092022193,
       0.002856840920924310581879845827302233374, 0.001213957125391211403289681847184056096,
      -0.001347227131676383658775986162936533219,-0.003905453568825525013236132920724230644,
      -0.005334169728864465893913848759666507249,-0.004759486744479700381926789987119263969,
      -0.002001671381602028627899603208106782404, 0.002200731660298483900045640737630492367,
       0.006326767221708212186881414851313820691, 0.008578929085475365395874192131486779545,
       0.007608160734253766391277373770662961761, 0.003184140060691302911988209700666629942,
      -0.003488248846301648335016531987662347092,-0.010006147282870192505299655749695375562,
      -0.013558745771432336932327267220443900442,-0.012036247337045483454809335910340450937,
      -0.005051693199621982467706349240188501426, 0.005561634076910163329565683909549989039,
       0.016071942561815044658857232207083143294, 0.022002174947367152818555879889572679531,
       0.019799738563965139231948242581893282477, 0.008459138643643174942932105864201730583,
      -0.009529048607261803374712805236868007341,-0.028361213005418703381188549883518135175,
      -0.040333835684212157590700087439472554252,-0.03814868318690734644293982569251966197,
      -0.017415187253869975764208888335815572646, 0.021484629846216300036454427413445955608,
       0.072858429076204614394107750285911606625, 0.126785617373732201196290247935394290835,
       0.171588240707207573265691280539613217115, 0.196987399839038984650230190709407906979,
       0.196987399839038984650230190709407906979, 0.171588240707207573265691280539613217115,
       0.126785617373732201196290247935394290835, 0.072858429076204614394107750285911606625,
       0.021484629846216300036454427413445955608,-0.017415187253869975764208888335815572646,
      -0.03814868318690734644293982569251966197,-0.040333835684212157590700087439472554252,
      -0.028361213005418703381188549883518135175,-0.009529048607261803374712805236868007341,
       0.008459138643643174942932105864201730583, 0.019799738563965139231948242581893282477,
       0.022002174947367152818555879889572679531, 0.016071942561815044658857232207083143294,
       0.005561634076910163329565683909549989039,-0.005051693199621982467706349240188501426,
      -0.012036247337045483454809335910340450937,-0.013558745771432336932327267220443900442,
      -0.010006147282870192505299655749695375562,-0.003488248846301648335016531987662347092,
       0.003184140060691302911988209700666629942, 0.007608160734253766391277373770662961761,
       0.008578929085475365395874192131486779545, 0.006326767221708212186881414851313820691,
       0.002200731660298483900045640737630492367,-0.002001671381602028627899603208106782404,
      -0.004759486744479700381926789987119263969,-0.005334169728864465893913848759666507249,
      -0.003905453568825525013236132920724230644,-0.001347227131676383658775986162936533219,
       0.001213957125391211403289681847184056096, 0.002856840920924310581879845827302233374,
       0.003166042258238703412803749515092022193, 0.002290297318945717225391334181949787308,
       0.000780061826223386878265131372245377861,-0.000693627791860814487019670782075309035,
      -0.001610306240851903242239373525990231428,-0.00176050993133213982619333926038507343,
      -0.001256902810726467792715177473894527793,-0.000422936841594838148356005902428478294,
       0.000372230362247760087138215290281095804, 0.000857842323225355054411300770311754604,
       0.000935068105496070158151600271168035761, 0.000669705996889420770122602899476760285,
       0.000227954566336893634263469077261277107,-0.000205138660856850552549265898072405889,
      -0.000489840873230431607388002390734982328,-0.000561775254636760605110590294231087682,
      -0.000430359456204313154097790272700763126,-0.000159218610761937911200758488661222145]
    comment: FIR Orden100 Hamming Fc=1000Hz Fs=10kHz
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: |-
      [-0.005230107296619057773157113189199662884,-0.012931101513474829028949031339834618848,
       0.01705008032939041642817024069245235296, 0.163563548040774831004995348848751746118,
       0.337547580439928718298858711932552978396, 0.337547580439928718298858711932552978396,
       0.163563548040774831004995348848751746118, 0.01705008032939041642817024069245235296, 
      -0.012931101513474829028949031339834618848,-0.005230107296619057773157113189199662884]
    type: fff
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '10000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '10000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_1, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_2, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_2_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_2_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_2_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cpp_0_2_0_0_1, '0']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0, '0']
- [customModule_filtro_FIR_cpp_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cpp_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cpp_0_1, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cpp_0_2, '0', qtgui_freq_sink_x_0_0, '0']
- [customModule_filtro_FIR_cpp_0_2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [customModule_filtro_FIR_cpp_0_2_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [customModule_filtro_FIR_cpp_0_2_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [customModule_filtro_FIR_cpp_0_2_0_0_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
