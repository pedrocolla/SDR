options:
  parameters:
    generate_options: qt_gui
    id: pruebas_filtro_cluster
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: customModule_filtro_FIR_cluster_log_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: |-
      [-0.000825921231325207655556142061215041394,-0.003169594663766307513635966941478727676,
      -0.007490150022454497569235343235050095245,-0.011392924569276900378933525814773020102,
      -0.007615797939547183648123507282434729859, 0.012597298745315127152522016729108145228,
       0.053172321589381205120261597585340496153, 0.108108486129147918219928214966785162687,
       0.161690634955576062470328224662807770073, 0.19492564700694975377004425354243721813, 
       0.19492564700694975377004425354243721813, 0.161690634955576062470328224662807770073,
       0.108108486129147918219928214966785162687, 0.053172321589381205120261597585340496153,
       0.012597298745315127152522016729108145228,-0.007615797939547183648123507282434729859,
      -0.011392924569276900378933525814773020102,-0.007490150022454497569235343235050095245,
      -0.003169594663766307513635966941478727676,-0.000825921231325207655556142061215041394]
    comment: FIR Orden20 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[0.00219904724846358,0.0173597084806051,0.0736728653074093,0.166238585186075,0.240529793777448,0.240529793777448,0.166238585186075,0.0736728653074093,0.0173597084806051,0.00219904724846358]'
    comment: FIR Orden10 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '1'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_1
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: |
      [0.000320362424863679048653991587869427349, 0.000915688554425526978278182532733353582, 0.001341155551857150162939347204371642874, 0.001357384060576103052345176003257165576,
       0.000666165963759637880237107765424298123,-0.000862117563136244259743012907648562759,
      -0.002909565635107423057365005902852317377,-0.004593586007083634223380208538856095402,
      -0.004694108232963912705204556630178558407,-0.002239460389777802890726166040735733986,
       0.002768200372038926316414775286034455348, 0.008877467039827944758623168297617667122,
       0.013341250581891686555202625186211662367, 0.013047725154040623607443194487132132053,
       0.00600214675023739898523933433693855477, -0.007217539561210916526645675617146480363,
      -0.022747566874395785258000657336197036784,-0.034000358909073762070374158383856411092,
      -0.03355980660790060243758858860019245185, -0.015880872119793384283914505772372649517,
       0.020178608380384446818744947904633590952, 0.070044835874201474834599423502368154004,
       0.124021431045317792607463047716009896249, 0.169786028110178871530777655607380438596,
       0.19603653203684243133686493365530623123,  0.19603653203684243133686493365530623123, 
       0.169786028110178871530777655607380438596, 0.124021431045317792607463047716009896249,
       0.070044835874201474834599423502368154004, 0.020178608380384446818744947904633590952,
      -0.015880872119793384283914505772372649517,-0.03355980660790060243758858860019245185, 
      -0.034000358909073762070374158383856411092,-0.022747566874395785258000657336197036784,
      -0.007217539561210916526645675617146480363, 0.00600214675023739898523933433693855477, 
       0.013047725154040623607443194487132132053, 0.013341250581891686555202625186211662367,
       0.008877467039827944758623168297617667122, 0.002768200372038926316414775286034455348,
      -0.002239460389777802890726166040735733986,-0.004694108232963912705204556630178558407,
      -0.004593586007083634223380208538856095402,-0.002909565635107423057365005902852317377,
      -0.000862117563136244259743012907648562759, 0.000666165963759637880237107765424298123,
       0.001357384060576103052345176003257165576, 0.001341155551857150162939347204371642874,
       0.000915688554425526978278182532733353582, 0.000320362424863679048653991587869427349]
    comment: FIR Orden50 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_2
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: |-
      [-0.000159218610761937911200758488661222145,-0.000430359456204313154097790272700763126,
      -0.000561775254636760605110590294231087682,-0.000489840873230431607388002390734982328,
      -0.000205138660856850552549265898072405889, 0.000227954566336893634263469077261277107,
       0.000669705996889420770122602899476760285, 0.000935068105496070158151600271168035761,
       0.000857842323225355054411300770311754604, 0.000372230362247760087138215290281095804,
      -0.000422936841594838148356005902428478294,-0.001256902810726467792715177473894527793,
      -0.00176050993133213982619333926038507343,-0.001610306240851903242239373525990231428,
      -0.000693627791860814487019670782075309035, 0.000780061826223386878265131372245377861,
       0.002290297318945717225391334181949787308, 0.003166042258238703412803749515092022193,
       0.002856840920924310581879845827302233374, 0.001213957125391211403289681847184056096,
      -0.001347227131676383658775986162936533219,-0.003905453568825525013236132920724230644,
      -0.005334169728864465893913848759666507249,-0.004759486744479700381926789987119263969,
      -0.002001671381602028627899603208106782404, 0.002200731660298483900045640737630492367,
       0.006326767221708212186881414851313820691, 0.008578929085475365395874192131486779545,
       0.007608160734253766391277373770662961761, 0.003184140060691302911988209700666629942,
      -0.003488248846301648335016531987662347092,-0.010006147282870192505299655749695375562,
      -0.013558745771432336932327267220443900442,-0.012036247337045483454809335910340450937,
      -0.005051693199621982467706349240188501426, 0.005561634076910163329565683909549989039,
       0.016071942561815044658857232207083143294, 0.022002174947367152818555879889572679531,
       0.019799738563965139231948242581893282477, 0.008459138643643174942932105864201730583,
      -0.009529048607261803374712805236868007341,-0.028361213005418703381188549883518135175,
      -0.040333835684212157590700087439472554252,-0.03814868318690734644293982569251966197,
      -0.017415187253869975764208888335815572646, 0.021484629846216300036454427413445955608,
       0.072858429076204614394107750285911606625, 0.126785617373732201196290247935394290835,
       0.171588240707207573265691280539613217115, 0.196987399839038984650230190709407906979,
       0.196987399839038984650230190709407906979, 0.171588240707207573265691280539613217115,
       0.126785617373732201196290247935394290835, 0.072858429076204614394107750285911606625,
       0.021484629846216300036454427413445955608,-0.017415187253869975764208888335815572646,
      -0.03814868318690734644293982569251966197,-0.040333835684212157590700087439472554252,
      -0.028361213005418703381188549883518135175,-0.009529048607261803374712805236868007341,
       0.008459138643643174942932105864201730583, 0.019799738563965139231948242581893282477,
       0.022002174947367152818555879889572679531, 0.016071942561815044658857232207083143294,
       0.005561634076910163329565683909549989039,-0.005051693199621982467706349240188501426,
      -0.012036247337045483454809335910340450937,-0.013558745771432336932327267220443900442,
      -0.010006147282870192505299655749695375562,-0.003488248846301648335016531987662347092,
       0.003184140060691302911988209700666629942, 0.007608160734253766391277373770662961761,
       0.008578929085475365395874192131486779545, 0.006326767221708212186881414851313820691,
       0.002200731660298483900045640737630492367,-0.002001671381602028627899603208106782404,
      -0.004759486744479700381926789987119263969,-0.005334169728864465893913848759666507249,
      -0.003905453568825525013236132920724230644,-0.001347227131676383658775986162936533219,
       0.001213957125391211403289681847184056096, 0.002856840920924310581879845827302233374,
       0.003166042258238703412803749515092022193, 0.002290297318945717225391334181949787308,
       0.000780061826223386878265131372245377861,-0.000693627791860814487019670782075309035,
      -0.001610306240851903242239373525990231428,-0.00176050993133213982619333926038507343,
      -0.001256902810726467792715177473894527793,-0.000422936841594838148356005902428478294,
       0.000372230362247760087138215290281095804, 0.000857842323225355054411300770311754604,
       0.000935068105496070158151600271168035761, 0.000669705996889420770122602899476760285,
       0.000227954566336893634263469077261277107,-0.000205138660856850552549265898072405889,
      -0.000489840873230431607388002390734982328,-0.000561775254636760605110590294231087682,
      -0.000430359456204313154097790272700763126,-0.000159218610761937911200758488661222145]
    comment: FIR Orden100 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000199592114281640,-0.000545856101709389,-0.000729728500295667,-0.000657605965706873,-0.000286159445493428,0.000331053924592096,0.00101191321422322,0.00146666854726569,0.00139251816774998,0.000623280434546477,-0.000728192842762910,-0.00221880314827820,-0.00317840400049726,-0.00296694093430161,-0.00130195876273399,0.00148958267909472,0.00444456626802692,0.00623915146631982,0.00571425962204630,0.00246408552277680,-0.00277525917632871,-0.00816765134611563,-0.0113327677462457,-0.0102823606065259,-0.00440318268661074,0.00493790806063944,0.0145123977518191,0.0201752561190250,0.0184110150932193,0.00796559260187310,-0.00907502220827756,-0.0272824044895005,-0.0391434311557355,-0.0373068176712742,-0.0171418417005508,0.0212613452053951,0.0724099826987643,0.126407856349381,0.171440013800715,0.197025533075752,0.197025533075752,0.171440013800715,0.126407856349381,0.0724099826987643,0.0212613452053951,-0.0171418417005508,-0.0373068176712742,-0.0391434311557355,-0.0272824044895005,-0.00907502220827756,0.00796559260187310,0.0184110150932193,0.0201752561190250,0.0145123977518191,0.00493790806063944,-0.00440318268661074,-0.0102823606065259,-0.0113327677462457,-0.00816765134611563,-0.00277525917632871,0.00246408552277680,0.00571425962204630,0.00623915146631982,0.00444456626802692,0.00148958267909472,-0.00130195876273399,-0.00296694093430161,-0.00317840400049726,-0.00221880314827820,-0.000728192842762910,0.000623280434546477,0.00139251816774998,0.00146666854726569,0.00101191321422322,0.000331053924592096,-0.000286159445493428,-0.000657605965706873,-0.000729728500295667,-0.000545856101709389,-0.000199592114281640]'
    comment: FIR Orden80 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000015756455548, -0.000041338387064, -0.000051217230377, -0.000041542662799, -0.000015912553039, 0.000015961020504, 0.000041923389995, 0.000052001813730, 0.000042227436311, 0.000016193336321, -0.000016261139515, -0.000042760028805, -0.000053099258932, -0.000043166797638, -0.000016571928758, 0.000016659633953, 0.000043855703029, 0.000054518728670, 0.000044368172936, 0.000017051172063, -0.000017159350769, -0.000045217879949, -0.000056269470368, -0.000045839057741, -0.000017633934773, 0.000017763164064, 0.000046854098819, 0.000058360821532, 0.000047587021396, 0.000018323113979, -0.000018473976867, -0.000048771975613, -0.000060802215751, -0.000049619712012, -0.000019121637262, 0.000019294723107, 0.000050979208318, 0.000063603189384, 0.000051944861995, 0.000020032464851, -0.000020228369824, -0.000053483582821, -0.000066773388989, -0.000054570294183, -0.000021058592018, 0.000021277919605, 0.000056292979437, 0.000070322579557, 0.000057503928641, 0.000022203051719, -0.000022446413287, -0.000059415380121, -0.000074260653602, -0.000060753790162, -0.000023468917522, 0.000023736932935, 0.000062858876415, 0.000078597641174, 0.000064328016525, 0.000024859306818, -0.000025152605119, -0.000066631678191, -0.000083343720876, -0.000068234867571, -0.000026377384358, 0.000026696604513, 0.000070742123250, 0.000088509231946, 0.000072482735165, 0.000028026366121, -0.000028372157842, -0.000075198687847, -0.000094104687503, -0.000077080154110, -0.000029809523565, 0.000030182548201, 0.000080009998203, 0.000100140789044, 0.000082035814077, 0.000031730188266, -0.000032131119784, -0.000085184843105, -0.000106628442285, -0.000087358572663, -0.000033791756989, 0.000034221283045, 0.000090732187660, 0.000113578774473, 0.000093057469634, 0.000035997697231, -0.000036456520334, -0.000096661188315, -0.000121003153275, -0.000099141742480, -0.000038351553263, 0.000038840392050, 0.000102981209235, 0.000128913207374, 0.000105620843367, 0.000040856952719, -0.000041376543342, -0.000109701840170, -0.000137320848940, -0.000112504457635, -0.000043517613784, 0.000044068711423, 0.000116832915915, 0.000146238298104, 0.000119802523935, 0.000046337353021, -0.000046920733531, -0.000124384537531, -0.000155678109636, -0.000127525256194, -0.000049320093902, 0.000049936555610, 0.000132367095454, 0.000165653202009, 0.000135683167527, 0.000052469876103, -0.000053120241766, -0.000140791294681, -0.000176176889068, -0.000144287096306, -0.000055790865634, 0.000056475984567, 0.000149668182211, 0.000187262914534, 0.000153348234559, 0.000059287365870, -0.000060008116273, -0.000159009176951, -0.000198925489618, -0.000162878158926, -0.000062963829589, 0.000063721121079, 0.000168826102318, 0.000211179334021, 0.000172888864411, 0.000066824872083, -0.000067619648458, -0.000179131221802, -0.000224039720658, -0.000183392801200, -0.000070875285470, 0.000071708527722, 0.000189937277751, 0.000237522524454, 0.000194402914835, 0.000075120054313, -0.000075992783922, -0.000201257533728, -0.000251644275622, -0.000205932690082, -0.000079564372671, 0.000080477655199, 0.000213105820762, 0.000266422217862, 0.000217996198863, 0.000084213662739, -0.000085168611763, -0.000225496587917, -0.000281874371993, -0.000230608152659, -0.000089073595227, 0.000090071376636, 0.000238444957604, 0.000298019605563, 0.000243783959864, 0.000094150111664, -0.000095191948373, -0.000251966786134, -0.000314877709083, -0.000257539788584, -0.000099449448833, 0.000100536625942, 0.000266078730081, 0.000332469479576, 0.000271892635500, 0.000104978165561, -0.000106112036019, -0.000280798319076, -0.000350816812243, -0.000286860401417, -0.000110743172126, 0.000111925162951, 0.000296144035734, 0.000369942801147, 0.000302461974276, 0.000116751762565, -0.000117983381685, -0.000312135403528, -0.000389871849914, -0.000318717320445, -0.000123011650226, 0.000124294494003, 0.000328793083502, 0.000410629793619, 0.000335647585248, 0.000129531006914, -0.000130866768449, -0.000346138980855, -0.000432244033129, -0.000353275203820, -0.000136318506083, 0.000137708984375, 0.000364196362561, 0.000454743683416, 0.000371624023499, 0.000143383370521, -0.000144830480596, -0.000382989987351, -0.000478159737490, -0.000390719439166, -0.000150735425113, 0.000152241209234, 0.000402546249571, 0.000502525247899, 0.000410588543127, 0.000158385155276, -0.000159951795376, -0.000422893338651, -0.000527875527983, -0.000431260291363, -0.000166343771810, 0.000167973603298, 0.000444061416162, 0.000554248375405, 0.000452765688246, 0.000174623282965, -0.000176318810092, -0.000466082812752, -0.000581684320865, -0.000475137992138, -0.000183236574692, 0.000185000487674, 0.000488992247576, 0.000610226905322, 0.000498412944646, 0.000192197500162, -0.000194032694301, -0.000512827073262, -0.000639922989605, -0.000522629026752, -0.000201520979812, 0.000203430576900, 0.000537627549917, 0.000670823100859, 0.000547827745544, 0.000211223113398, -0.000213210485707, -0.000563437152256, -0.000702981821042, -0.000574053955880, -0.000221321305747, 0.000223390102998, 0.000590302914590, 0.000736458223502, 0.000601356222024, 0.000231834408206, -0.000233988587937, -0.000618275819227, -0.000771316364717, -0.000629787225168, -0.000242782878108, 0.000245026739964, 0.000647411234767, 0.000807625839475, 0.000659404223752, 0.000254188958987, -0.000256527183524, -0.000677769411921, -0.000845462409237, -0.000690269574721, -0.000266076884761, 0.000268514577483, 0.000709416045846, 0.000884908715172, 0.000722451325349, 0.000278473111674, -0.000281015853134, -0.000742422915642, -0.000926055089472, -0.000756023887005, -0.000291406582503, 0.000294060485472, 0.000776868613626, 0.000969000481115, 0.000791068804407, 0.000304909028391, -0.000307680803279, -0.000812839379455, -0.001013853515352, -0.000827675636535, -0.000319015314695, 0.000321912344656, 0.000850430057101, 0.001060733710021, 0.000865942968590, 0.000333763838547, -0.000336794265978, -0.000889745196332, -0.001109772876444, -0.000905979578290, -0.000349196987359, 0.000352369813861, 0.000930900324806, 0.001161116738458, 0.000947905784738, 0.000365361669476, -0.000368686871786, -0.000974023422452, -0.001214926810264, -0.000991855014066, -0.000382309930568, 0.000385798595535, 0.001019256636696, 0.001271382582720, 0.001037975623664, 0.000400099672400, -0.000403764154737, -0.001066758285732, -0.001330684078862, -0.001086433036241, -0.000418795494369, 0.000422649601815, 0.001116705207939, 0.001393054853553, 0.001137412246932, 0.000438469683015, -0.000442528894622, -0.001169295529313, -0.001458745530035, -0.001191120781852, -0.000459203380787, 0.000463485105462, 0.001224751938382, 0.001528037988995, 0.001247792205907, 0.000481087973149, -0.000485611857393, -0.001283325580647, -0.001601250355142, -0.001307690302689, -0.000504226743155, 0.000509015039277, 0.001345300713778, 0.001678742964274, 0.001371114081687, 0.000528736855702, -0.000533814864848, -0.001411000302871, -0.001760925543498, -0.001438403810463, -0.000554751750736, 0.000560148359101, 0.001480792784995, 0.001848265902524, 0.001509948325276, 0.000582424047298, -0.000588172379209, -0.001555100298526, -0.001941300520651, -0.001586193947960, -0.000611929090338, 0.000618067309063, 0.001634408761251, 0.002040647530167, 0.001667655436536, 0.000643469312689, -0.000650041609481, -0.001719280300790, -0.002147022753973, -0.001754929532244, -0.000677279639517, 0.000684337464624, 0.001810368703950, 0.002261259670036, 0.001848711850896, 0.000713634238040, -0.000721237845687, -0.001908438776669, -0.002384334472340, -0.001949818123282, -0.000752855020168, 0.000761075425074, 0.002014390820426, 0.002517397813887, 0.002059211149747, 0.000795322453264, -0.000804243932521, -0.002129291875567, -0.002661815407252, -0.002178035346845, -0.000841489444763, 0.000851212771058, 0.002254416019855, 0.002819220507221, 0.002307661503975, 0.000891899371118, -0.000902546039456, -0.002391296939814, -0.002991582540820, -0.002449745453106, -0.000947209769948, 0.000958927593184, 0.002541797368930, 0.003181297994540, 0.002606305973475, 0.001008223885546, -0.001021194505307, -0.002708202063193, -0.003391312461605, -0.002779829714215, -0.001075933282583, 0.001090382406575, 0.002893344179917, 0.003625287068654, 0.002973414737631, 0.001151576340234, -0.001167787934513, -0.003100779952975, -0.003887829324141, -0.003190970352724, -0.001236719988532, 0.001255056329307, 0.003335034662726, 0.004184819488531, 0.003437500793556, 0.001333376225601, -0.001354306840320, -0.003601956328561, -0.004523881996105, -0.003719516871335, -0.001444172000982, 0.001468316460624, 0.003909236498683, 0.004915083157226, 0.004045648430728, 0.001572603337986, -0.001600796300133, -0.004267198109834, -0.005371992876971, -0.004427582002401, -0.001723426818763, 0.001756820090013, 0.004690025135565, 0.005913353067657, 0.004881544658886, 0.001903283633961, -0.001943512385920, -0.005197752839516, -0.006565799792853, -0.005430745194530, -0.002121735092820, 0.002171200727563, 0.005819630614698, 0.007368506921687, 0.006109580011258, 0.002393065176749, -0.002455442855113, -0.006600105214224, -0.008381544703027, -0.006971295893759, -0.002739606376454, 0.002820816721291, 0.007610162095838, 0.009701953942438, 0.008102950662332, 0.003198336842893, -0.003308564751614, -0.008970605019981, -0.011497355639942, -0.009657310409672, -0.003835238890642, 0.003993598421558, 0.010905054278957, 0.014084373472008, 0.011929254504734, 0.004780669943120, -0.005027663719499, -0.013878887994348, -0.018141494806161, -0.015571098778628, -0.006333193369032, 0.006771814461036, 0.019046941844807, 0.025432798139517, 0.022369631359549, 0.009360068847401, -0.010347222380822, -0.030281325466819, -0.042426590272733, -0.039609467728389, -0.017882235624841, 0.021858054493657, 0.073580522258082, 0.127337689515127, 0.171703506810578, 0.196758291122689, 0.196758291122689, 0.171703506810578, 0.127337689515127, 0.073580522258082, 0.021858054493657, -0.017882235624841, -0.039609467728389, -0.042426590272733, -0.030281325466819, -0.010347222380822, 0.009360068847401, 0.022369631359549, 0.025432798139517, 0.019046941844807, 0.006771814461036, -0.006333193369032, -0.015571098778628, -0.018141494806161, -0.013878887994348, -0.005027663719499, 0.004780669943120, 0.011929254504734, 0.014084373472008, 0.010905054278957, 0.003993598421558, -0.003835238890642, -0.009657310409672, -0.011497355639942, -0.008970605019981, -0.003308564751614, 0.003198336842893, 0.008102950662332, 0.009701953942438, 0.007610162095838, 0.002820816721291, -0.002739606376454, -0.006971295893759, -0.008381544703027, -0.006600105214224, -0.002455442855113, 0.002393065176749, 0.006109580011258, 0.007368506921687, 0.005819630614698, 0.002171200727563, -0.002121735092820, -0.005430745194530, -0.006565799792853, -0.005197752839516, -0.001943512385920, 0.001903283633961, 0.004881544658886, 0.005913353067657, 0.004690025135565, 0.001756820090013, -0.001723426818763, -0.004427582002401, -0.005371992876971, -0.004267198109834, -0.001600796300133, 0.001572603337986, 0.004045648430728, 0.004915083157226, 0.003909236498683, 0.001468316460624, -0.001444172000982, -0.003719516871335, -0.004523881996105, -0.003601956328561, -0.001354306840320, 0.001333376225601, 0.003437500793556, 0.004184819488531, 0.003335034662726, 0.001255056329307, -0.001236719988532, -0.003190970352724, -0.003887829324141, -0.003100779952975, -0.001167787934513, 0.001151576340234, 0.002973414737631, 0.003625287068654, 0.002893344179917, 0.001090382406575, -0.001075933282583, -0.002779829714215, -0.003391312461605, -0.002708202063193, -0.001021194505307, 0.001008223885546, 0.002606305973475, 0.003181297994540, 0.002541797368930, 0.000958927593184, -0.000947209769948, -0.002449745453106, -0.002991582540820, -0.002391296939814, -0.000902546039456, 0.000891899371118, 0.002307661503975, 0.002819220507221, 0.002254416019855, 0.000851212771058, -0.000841489444763, -0.002178035346845, -0.002661815407252, -0.002129291875567, -0.000804243932521, 0.000795322453264, 0.002059211149747, 0.002517397813887, 0.002014390820426, 0.000761075425074, -0.000752855020168, -0.001949818123282, -0.002384334472340, -0.001908438776669, -0.000721237845687, 0.000713634238040, 0.001848711850896, 0.002261259670036, 0.001810368703950, 0.000684337464624, -0.000677279639517, -0.001754929532244, -0.002147022753973, -0.001719280300790, -0.000650041609481, 0.000643469312689, 0.001667655436536, 0.002040647530167, 0.001634408761251, 0.000618067309063, -0.000611929090338, -0.001586193947960, -0.001941300520651, -0.001555100298526, -0.000588172379209, 0.000582424047298, 0.001509948325276, 0.001848265902524, 0.001480792784995, 0.000560148359101, -0.000554751750736, -0.001438403810463, -0.001760925543498, -0.001411000302871, -0.000533814864848, 0.000528736855702, 0.001371114081687, 0.001678742964274, 0.001345300713778, 0.000509015039277, -0.000504226743155, -0.001307690302689, -0.001601250355142, -0.001283325580647, -0.000485611857393, 0.000481087973149, 0.001247792205907, 0.001528037988995, 0.001224751938382, 0.000463485105462, -0.000459203380787, -0.001191120781852, -0.001458745530035, -0.001169295529313, -0.000442528894622, 0.000438469683015, 0.001137412246932, 0.001393054853553, 0.001116705207939, 0.000422649601815, -0.000418795494369, -0.001086433036241, -0.001330684078862, -0.001066758285732, -0.000403764154737, 0.000400099672400, 0.001037975623664, 0.001271382582720, 0.001019256636696, 0.000385798595535, -0.000382309930568, -0.000991855014066, -0.001214926810264, -0.000974023422452, -0.000368686871786, 0.000365361669476, 0.000947905784738, 0.001161116738458, 0.000930900324806, 0.000352369813861, -0.000349196987359, -0.000905979578290, -0.001109772876444, -0.000889745196332, -0.000336794265978, 0.000333763838547, 0.000865942968590, 0.001060733710021, 0.000850430057101, 0.000321912344656, -0.000319015314695, -0.000827675636535, -0.001013853515352, -0.000812839379455, -0.000307680803279, 0.000304909028391, 0.000791068804407, 0.000969000481115, 0.000776868613626, 0.000294060485472, -0.000291406582503, -0.000756023887005, -0.000926055089472, -0.000742422915642, -0.000281015853134, 0.000278473111674, 0.000722451325349, 0.000884908715172, 0.000709416045846, 0.000268514577483, -0.000266076884761, -0.000690269574721, -0.000845462409237, -0.000677769411921, -0.000256527183524, 0.000254188958987, 0.000659404223752, 0.000807625839475, 0.000647411234767, 0.000245026739964, -0.000242782878108, -0.000629787225168, -0.000771316364717, -0.000618275819227, -0.000233988587937, 0.000231834408206, 0.000601356222024, 0.000736458223502, 0.000590302914590, 0.000223390102998, -0.000221321305747, -0.000574053955880, -0.000702981821042, -0.000563437152256, -0.000213210485707, 0.000211223113398, 0.000547827745544, 0.000670823100859, 0.000537627549917, 0.000203430576900, -0.000201520979812, -0.000522629026752, -0.000639922989605, -0.000512827073262, -0.000194032694301, 0.000192197500162, 0.000498412944646, 0.000610226905322, 0.000488992247576, 0.000185000487674, -0.000183236574692, -0.000475137992138, -0.000581684320865, -0.000466082812752, -0.000176318810092, 0.000174623282965, 0.000452765688246, 0.000554248375405, 0.000444061416162, 0.000167973603298, -0.000166343771810, -0.000431260291363, -0.000527875527983, -0.000422893338651, -0.000159951795376, 0.000158385155276, 0.000410588543127, 0.000502525247899, 0.000402546249571, 0.000152241209234, -0.000150735425113, -0.000390719439166, -0.000478159737490, -0.000382989987351, -0.000144830480596, 0.000143383370521, 0.000371624023499, 0.000454743683416, 0.000364196362561, 0.000137708984375, -0.000136318506083, -0.000353275203820, -0.000432244033129, -0.000346138980855, -0.000130866768449, 0.000129531006914, 0.000335647585248, 0.000410629793619, 0.000328793083502, 0.000124294494003, -0.000123011650226, -0.000318717320445, -0.000389871849914, -0.000312135403528, -0.000117983381685, 0.000116751762565, 0.000302461974276, 0.000369942801147, 0.000296144035734, 0.000111925162951, -0.000110743172126, -0.000286860401417, -0.000350816812243, -0.000280798319076, -0.000106112036019, 0.000104978165561, 0.000271892635500, 0.000332469479576, 0.000266078730081, 0.000100536625942, -0.000099449448833, -0.000257539788584, -0.000314877709083, -0.000251966786134, -0.000095191948373, 0.000094150111664, 0.000243783959864, 0.000298019605563, 0.000238444957604, 0.000090071376636, -0.000089073595227, -0.000230608152659, -0.000281874371993, -0.000225496587917, -0.000085168611763, 0.000084213662739, 0.000217996198863, 0.000266422217862, 0.000213105820762, 0.000080477655199, -0.000079564372671, -0.000205932690082, -0.000251644275622, -0.000201257533728, -0.000075992783922, 0.000075120054313, 0.000194402914835, 0.000237522524454, 0.000189937277751, 0.000071708527722, -0.000070875285470, -0.000183392801200, -0.000224039720658, -0.000179131221802, -0.000067619648458, 0.000066824872083, 0.000172888864411, 0.000211179334021, 0.000168826102318, 0.000063721121079, -0.000062963829589, -0.000162878158926, -0.000198925489618, -0.000159009176951, -0.000060008116273, 0.000059287365870, 0.000153348234559, 0.000187262914534, 0.000149668182211, 0.000056475984567, -0.000055790865634, -0.000144287096306, -0.000176176889068, -0.000140791294681, -0.000053120241766, 0.000052469876103, 0.000135683167527, 0.000165653202009, 0.000132367095454, 0.000049936555610, -0.000049320093902, -0.000127525256194, -0.000155678109636, -0.000124384537531, -0.000046920733531, 0.000046337353021, 0.000119802523935, 0.000146238298104, 0.000116832915915, 0.000044068711423, -0.000043517613784, -0.000112504457635, -0.000137320848940, -0.000109701840170, -0.000041376543342, 0.000040856952719, 0.000105620843367, 0.000128913207374, 0.000102981209235, 0.000038840392050, -0.000038351553263, -0.000099141742480, -0.000121003153275, -0.000096661188315, -0.000036456520334, 0.000035997697231, 0.000093057469634, 0.000113578774473, 0.000090732187660, 0.000034221283045, -0.000033791756989, -0.000087358572663, -0.000106628442285, -0.000085184843105, -0.000032131119784, 0.000031730188266, 0.000082035814077, 0.000100140789044, 0.000080009998203, 0.000030182548201, -0.000029809523565, -0.000077080154110, -0.000094104687503, -0.000075198687847, -0.000028372157842, 0.000028026366121, 0.000072482735165, 0.000088509231946, 0.000070742123250, 0.000026696604513, -0.000026377384358, -0.000068234867571, -0.000083343720876, -0.000066631678191, -0.000025152605119, 0.000024859306818, 0.000064328016525, 0.000078597641174, 0.000062858876415, 0.000023736932935, -0.000023468917522, -0.000060753790162, -0.000074260653602, -0.000059415380121, -0.000022446413287, 0.000022203051719, 0.000057503928641, 0.000070322579557, 0.000056292979437, 0.000021277919605, -0.000021058592018, -0.000054570294183, -0.000066773388989, -0.000053483582821, -0.000020228369824, 0.000020032464851, 0.000051944861995, 0.000063603189384, 0.000050979208318, 0.000019294723107, -0.000019121637262, -0.000049619712012, -0.000060802215751, -0.000048771975613, -0.000018473976867, 0.000018323113979, 0.000047587021396, 0.000058360821532, 0.000046854098819, 0.000017763164064, -0.000017633934773, -0.000045839057741, -0.000056269470368, -0.000045217879949, -0.000017159350769, 0.000017051172063, 0.000044368172936, 0.000054518728670, 0.000043855703029, 0.000016659633953, -0.000016571928758, -0.000043166797638, -0.000053099258932, -0.000042760028805, -0.000016261139515, 0.000016193336321, 0.000042227436311, 0.000052001813730, 0.000041923389995, 0.000015961020504, -0.000015912553039, -0.000041542662799, -0.000051217230377, -0.000041338387064, -0.000015756455548]'
    comment: FIR Orden1000 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000079150277786496, -0.000209921742356116, -0.000264385426139452, -0.000219167354914234, -0.000086242118197459, 0.000089297117751165, 0.000243200281068434, 0.000314055248885605, 0.000266449651644203, 0.000107088417344122, -0.000113004996288863, -0.000312960111828507, -0.000410041239102528, -0.000352203865769962, -0.000143017128168977, 0.000152188086625030, 0.000424278071240723, 0.000558705962283870, 0.000481653643213283, 0.000196054984538744, -0.000208907194252998, -0.000582646053726998, -0.000766967275348513, -0.000660509307205082, -0.000268430258435725, 0.000285441761539776, 0.000794177243901077, 0.001042576956490681, 0.000895214061843449, 0.000362675413942697, -0.000384401873935895, -0.001065925969566090, -0.001394551872581205, -0.001193324380079444, -0.000481785557137542, 0.000508901080079387, 0.001406381302946529, 0.001833839819895157, 0.001564098121022401, 0.000629463820298950, -0.000662824594495586, -0.001826235039551412, -0.002374358562690782, -0.002019415388339151, -0.000810507034152225, 0.000851252599206194, 0.002339599343130408, 0.003034651433806035, 0.002575253679608456, 0.001031427093219402, -0.001081146411770370, -0.002965993391074168, -0.003840607172231810, -0.003254128964823660, -0.001301487110264273, 0.001362501982117771, 0.003733711556765202, 0.004830112496889707, 0.004089310695670300, 0.001634508198315701, -0.001710382098114138, -0.004685821745570808, -0.006061431952791485, -0.005132503965576305, -0.002052203575400155, 0.002148715567011344, 0.005891533226821172, 0.007629318076058593, 0.006468842081637839, 0.002590789060721003, -0.002717956074606679, -0.007469518057924986, -0.009698677682063145, -0.008248834133699803, -0.003315362759160162, 0.003492110196667817, 0.009640977547392012, 0.012583088742885922, 0.010764856103723833, 0.004355313407255879, -0.004621945806013870, -0.012868714049295127, -0.016957850880153124, -0.014666656492125646, -0.006008235335192613, 0.006467568515860151, 0.018305167194089561, 0.024584240506755600, 0.021738944288436948, 0.009140697339895561, -0.010149608111908398, -0.029821596295869144, -0.041930558660147194, -0.039267626110914541, -0.017774922548175830, 0.021774854813464313, 0.073429820116212172, 0.127244985255450083, 0.171729731532833108, 0.196875030308461374, 0.196875030308461374, 0.171729731532833108, 0.127244985255450083, 0.073429820116212172, 0.021774854813464313, -0.017774922548175830, -0.039267626110914541, -0.041930558660147194, -0.029821596295869144, -0.010149608111908398, 0.009140697339895561, 0.021738944288436948, 0.024584240506755600, 0.018305167194089561, 0.006467568515860151, -0.006008235335192613, -0.014666656492125646, -0.016957850880153124, -0.012868714049295127, -0.004621945806013870, 0.004355313407255879, 0.010764856103723833, 0.012583088742885922, 0.009640977547392012, 0.003492110196667817, -0.003315362759160162, -0.008248834133699803, -0.009698677682063145, -0.007469518057924986, -0.002717956074606679, 0.002590789060721003, 0.006468842081637839, 0.007629318076058593, 0.005891533226821172, 0.002148715567011344, -0.002052203575400155, -0.005132503965576305, -0.006061431952791485, -0.004685821745570808, -0.001710382098114138, 0.001634508198315701, 0.004089310695670300, 0.004830112496889707, 0.003733711556765202, 0.001362501982117771, -0.001301487110264273, -0.003254128964823660, -0.003840607172231810, -0.002965993391074168, -0.001081146411770370, 0.001031427093219402, 0.002575253679608456, 0.003034651433806035, 0.002339599343130408, 0.000851252599206194, -0.000810507034152225, -0.002019415388339151, -0.002374358562690782, -0.001826235039551412, -0.000662824594495586, 0.000629463820298950, 0.001564098121022401, 0.001833839819895157, 0.001406381302946529, 0.000508901080079387, -0.000481785557137542, -0.001193324380079444, -0.001394551872581205, -0.001065925969566090, -0.000384401873935895, 0.000362675413942697, 0.000895214061843449, 0.001042576956490681, 0.000794177243901077, 0.000285441761539776, -0.000268430258435725, -0.000660509307205082, -0.000766967275348513, -0.000582646053726998, -0.000208907194252998, 0.000196054984538744, 0.000481653643213283, 0.000558705962283870, 0.000424278071240723, 0.000152188086625030, -0.000143017128168977, -0.000352203865769962, -0.000410041239102528, -0.000312960111828507, -0.000113004996288863, 0.000107088417344122, 0.000266449651644203, 0.000314055248885605, 0.000243200281068434, 0.000089297117751165, -0.000086242118197459, -0.000219167354914234, -0.000264385426139452, -0.000209921742356116, -0.000079150277786496]'
    comment: FIR Orden200 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000052664560326427, -0.000138982294646225, -0.000173614034176965, -0.000142308171877503, -0.000055210923943513, 0.000056214639500261, 0.000150198924709347, 0.000189900653339477, 0.000157481197459339, 0.000061783601914917, -0.000063578872022731, -0.000171589164947571, -0.000218996529932790, -0.000183207753520964, -0.000072460711741351, 0.000075121433650896, 0.000204113402710590, 0.000262097782612304, 0.000220463167036688, 0.000087617860479558, -0.000091221151202018, -0.000248772280571049, -0.000320452795488309, -0.000270267213767256, -0.000107648514996675, 0.000112275650861880, 0.000306618277032386, 0.000395377468486387, 0.000333697252097992, 0.000132969338462081, -0.000138707031180432, -0.000378771485934500, -0.000488275928738882, -0.000411906007542890, -0.000164027397494699, 0.000170969506786126, 0.000466440833534323, 0.000600668328886795, 0.000506145405215077, 0.000201309807276057, -0.000209559626197974, -0.000570952414386601, -0.000734227945098751, -0.000617798357788689, -0.000245356591473419, 0.000255029892526355, 0.000693787262380757, 0.000890830633310180, 0.000748421153836214, 0.000296777837542873, -0.000308006943596595, -0.000836631799781000, -0.001072620939560578, -0.000899800173772196, -0.000356276675276961, 0.000369215932310696, 0.001001445580788709, 0.001282101001279816, 0.001074028276648784, 0.000424680276707983, -0.000439513476394444, -0.001190553019800853, -0.001522251166054140, -0.001273608659366247, -0.000502982099115837, 0.000519932663526842, 0.001406768987479245, 0.001796695567946482, 0.001501597807378891, 0.000592400189471020, -0.000611745347621642, -0.001653573183032881, -0.002109932722162108, -0.001761805221194289, -0.000694458917654027, 0.000716549779555629, 0.001935356295370576, 0.002467662255975803, 0.002059077487820136, 0.000811105682755263, -0.000836396241933384, -0.002257774396532961, -0.002877257325580160, -0.002399710842815723, -0.000944881184426119, 0.000973971212473288, 0.002628270962240470, 0.003348463974672182, 0.002792065077196189, 0.001099174142127982, -0.001132874377519377, -0.003056866523888106, -0.003894465214203550, -0.003247503220524339, -0.001278613602844561, 0.001318048007341633, 0.003557390726771337, 0.004533552579471962, 0.003781878079546884, 0.001489694070541628, -0.001536466296611596, -0.004149475718216692, -0.005291852353912775, -0.004417976894028494, -0.001741812415072530, 0.001798288998801742, 0.004861923061881429, 0.006207974546040302, 0.005189731779829449, 0.002049072271450546, -0.002118890603790100, -0.005738692437811711, -0.007341378685369304, -0.006149888765110586, -0.002433612448875023, 0.002522653126727871, 0.006850250869669919, 0.008788458614236298, 0.007384977846459599, 0.002932208036187964, -0.003050614747799859, -0.008316865100389986, -0.010716169843406035, -0.009047226418257406, -0.003610635943512006, 0.003777482460179548, 0.010361624244803256, 0.013440487220450997, 0.011430997743068841, 0.004599061011609792, -0.004854815690875352, -0.013449438569524009, -0.017639352744952028, -0.015188200856553386, -0.006195908223966438, 0.006643551934291894, 0.018734914720652304, 0.025076684968066643, 0.022105627615469338, 0.009268507693460453, -0.010265028821305512, -0.030090950575267724, -0.042222402656397075, -0.039469977186876511, -0.017839065904702047, 0.021825474267784487, 0.073525243916520266, 0.127312659051094151, 0.171733270611453770, 0.196828796396995576, 0.196828796396995576, 0.171733270611453770, 0.127312659051094151, 0.073525243916520266, 0.021825474267784487, -0.017839065904702047, -0.039469977186876511, -0.042222402656397075, -0.030090950575267724, -0.010265028821305512, 0.009268507693460453, 0.022105627615469338, 0.025076684968066643, 0.018734914720652304, 0.006643551934291894, -0.006195908223966438, -0.015188200856553386, -0.017639352744952028, -0.013449438569524009, -0.004854815690875352, 0.004599061011609792, 0.011430997743068841, 0.013440487220450997, 0.010361624244803256, 0.003777482460179548, -0.003610635943512006, -0.009047226418257406, -0.010716169843406035, -0.008316865100389986, -0.003050614747799859, 0.002932208036187964, 0.007384977846459599, 0.008788458614236298, 0.006850250869669919, 0.002522653126727871, -0.002433612448875023, -0.006149888765110586, -0.007341378685369304, -0.005738692437811711, -0.002118890603790100, 0.002049072271450546, 0.005189731779829449, 0.006207974546040302, 0.004861923061881429, 0.001798288998801742, -0.001741812415072530, -0.004417976894028494, -0.005291852353912775, -0.004149475718216692, -0.001536466296611596, 0.001489694070541628, 0.003781878079546884, 0.004533552579471962, 0.003557390726771337, 0.001318048007341633, -0.001278613602844561, -0.003247503220524339, -0.003894465214203550, -0.003056866523888106, -0.001132874377519377, 0.001099174142127982, 0.002792065077196189, 0.003348463974672182, 0.002628270962240470, 0.000973971212473288, -0.000944881184426119, -0.002399710842815723, -0.002877257325580160, -0.002257774396532961, -0.000836396241933384, 0.000811105682755263, 0.002059077487820136, 0.002467662255975803, 0.001935356295370576, 0.000716549779555629, -0.000694458917654027, -0.001761805221194289, -0.002109932722162108, -0.001653573183032881, -0.000611745347621642, 0.000592400189471020, 0.001501597807378891, 0.001796695567946482, 0.001406768987479245, 0.000519932663526842, -0.000502982099115837, -0.001273608659366247, -0.001522251166054140, -0.001190553019800853, -0.000439513476394444, 0.000424680276707983, 0.001074028276648784, 0.001282101001279816, 0.001001445580788709, 0.000369215932310696, -0.000356276675276961, -0.000899800173772196, -0.001072620939560578, -0.000836631799781000, -0.000308006943596595, 0.000296777837542873, 0.000748421153836214, 0.000890830633310180, 0.000693787262380757, 0.000255029892526355, -0.000245356591473419, -0.000617798357788689, -0.000734227945098751, -0.000570952414386601, -0.000209559626197974, 0.000201309807276057, 0.000506145405215077, 0.000600668328886795, 0.000466440833534323, 0.000170969506786126, -0.000164027397494699, -0.000411906007542890, -0.000488275928738882, -0.000378771485934500, -0.000138707031180432, 0.000132969338462081, 0.000333697252097992, 0.000395377468486387, 0.000306618277032386, 0.000112275650861880, -0.000107648514996675, -0.000270267213767256, -0.000320452795488309, -0.000248772280571049, -0.000091221151202018, 0.000087617860479558, 0.000220463167036688, 0.000262097782612304, 0.000204113402710590, 0.000075121433650896, -0.000072460711741351, -0.000183207753520964, -0.000218996529932790, -0.000171589164947571, -0.000063578872022731, 0.000061783601914917, 0.000157481197459339, 0.000189900653339477, 0.000150198924709347, 0.000056214639500261, -0.000055210923943513, -0.000142308171877503, -0.000173614034176965, -0.000138982294646225, -0.000052664560326427]'
    comment: FIR Orden300 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '80000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000039460077482133, -0.000103902288077706, -0.000129356425201160, -0.000105557906420185, -0.000040726624041752, 0.000041195497588765, 0.000109242825450937, 0.000136957410949681, 0.000112527715832246, 0.000043706738152633, -0.000044498004194751, -0.000118744796208458, -0.000149775174295489, -0.000123777304921940, -0.000048344354295482, 0.000049480902522150, 0.000132706335130022, 0.000168180143307320, 0.000139607956874713, 0.000054755185033601, -0.000056260560166241, -0.000151433873201800, -0.000192553363937692, -0.000160329854353107, -0.000063058466593141, 0.000064956999153449, 0.000175243768580115, 0.000223288619765818, 0.000186263881482954, 0.000073377681668811, -0.000075694654555456, -0.000204464389965927, -0.000260795132031892, -0.000217743913088988, -0.000085841475427806, 0.000088603333694827, 0.000239438745337938, 0.000305500959846105, 0.000255119692416442, 0.000100584805088331, -0.000103819418115250, -0.000280527771406576, -0.000357857249612805, -0.000298760423406515, -0.000117750373436348, 0.000121487361009229, 0.000328114428169049, 0.000418343520512935, 0.000349059235836180, 0.000137490409632074, -0.000141761546497089, -0.000382608780796951, -0.000487474222275292, -0.000406438723822314, -0.000159968877679458, 0.000164808595136697, 0.000444454300857244, 0.000565806866512189, 0.000471357813848761, 0.000185364215425929, -0.000190810223851526, -0.000514135684863864, -0.000653952119299684, -0.000544320292542225, -0.000213872736947355, 0.000219966800262899, 0.000592188576464862, 0.000752586358514760, 0.000625885423905103, 0.000245712871528700, -0.000252501774287306, -0.000679211697876362, -0.000862467356249743, -0.000716681220662349, -0.000281130467306443, 0.000288667228263288, 0.000775882059036252, 0.000984453961140010, 0.000817421119396032, 0.000320405463014221, -0.000328750867302930, -0.000882974137750482, -0.001119530952228397, -0.000928925065719997, -0.000363860336052400, 0.000373084883642611, 0.001001384238134862, 0.001268840651620333, 0.001052146375983091, 0.000411870882593800, -0.000422057286948644, -0.001132161679039410, -0.001433723472939838, -0.001188206254554098, -0.000464880095884493, 0.000476126518877273, 0.001276549101858993, 0.001615770431422777, 0.001338438585676841, 0.000523416213624876, -0.000535840498947298, -0.001436035116324803, -0.001816891882241582, -0.001504448704003315, -0.000588116453682279, 0.000601861734148811, 0.001612423879409072, 0.002039408598203782, 0.001688191466843147, 0.000659758628755083, -0.000675000854171952, -0.001807928279099842, -0.002286174091331370, -0.001892076412474446, -0.000739303855389062, 0.000756262052132311, 0.002025296590730711, 0.002560741400051443, 0.002119111609339397, 0.000827955170450991, -0.000846905661554407, -0.002267987501713681, -0.002867594387946212, -0.002373103868945933, -0.000927239418214087, 0.000948535908910334, 0.002540416507340937, 0.003212474660183158, 0.002658942882507037, 0.001039123949022342, -0.001063226508100096, -0.002848310112984477, -0.003602853637616180, -0.002983013419355117, -0.001166186718647687, 0.001193704618627451, 0.003199227230106886, 0.004048631035069645, 0.003353808433641618, 0.001311870668104864, -0.001343627485716105, -0.003603347761256062, -0.004563197510918915, -0.003782867499688354, -0.001480875519825088, 0.001518011268785471, 0.004074703133273417, 0.005165104222211995, 0.004286261634995836, 0.001679782214517301, -0.001723919651320893, -0.004633167670971548, -0.005880786429572556, -0.004887035730074962, -0.001918088927496760, 0.001971616538801555, 0.005307822939963972, 0.006749209140574700, 0.005619416162477828, 0.002210014333872669, -0.002276594045175350, -0.006142943167927842, -0.007830228638437383, -0.006536476191717369, -0.002577824547437462, 0.002663363723823348, 0.007209340136788023, 0.009220671558891358, 0.007725101064716641, 0.003058432192213569, -0.003173103008623878, -0.008627649300617723, -0.011087953784340552, -0.009337893905410058, -0.003717758748300297, 0.003880664286864859, 0.010621341876692142, 0.013748523243738453, 0.011669600349728283, 0.004686114519483763, -0.004937751303915780, -0.013655701172862127, -0.017880774347525136, -0.015372485559676210, -0.006262055341370054, 0.006705425396368893, 0.018885633316461276, 0.025248954535936563, 0.022233562076474755, 0.009312971797331888, -0.010305051411205043, -0.030183983345949482, -0.042322692662793614, -0.039539019058665928, -0.017860708664654550, 0.021842214138325069, 0.073555410086781195, 0.127330854571599733, 0.171727218118240710, 0.196804330230715058, 0.196804330230715058, 0.171727218118240710, 0.127330854571599733, 0.073555410086781195, 0.021842214138325069, -0.017860708664654550, -0.039539019058665928, -0.042322692662793614, -0.030183983345949482, -0.010305051411205043, 0.009312971797331888, 0.022233562076474755, 0.025248954535936563, 0.018885633316461276, 0.006705425396368893, -0.006262055341370054, -0.015372485559676210, -0.017880774347525136, -0.013655701172862127, -0.004937751303915780, 0.004686114519483763, 0.011669600349728283, 0.013748523243738453, 0.010621341876692142, 0.003880664286864859, -0.003717758748300297, -0.009337893905410058, -0.011087953784340552, -0.008627649300617723, -0.003173103008623878, 0.003058432192213569, 0.007725101064716641, 0.009220671558891358, 0.007209340136788023, 0.002663363723823348, -0.002577824547437462, -0.006536476191717369, -0.007830228638437383, -0.006142943167927842, -0.002276594045175350, 0.002210014333872669, 0.005619416162477828, 0.006749209140574700, 0.005307822939963972, 0.001971616538801555, -0.001918088927496760, -0.004887035730074962, -0.005880786429572556, -0.004633167670971548, -0.001723919651320893, 0.001679782214517301, 0.004286261634995836, 0.005165104222211995, 0.004074703133273417, 0.001518011268785471, -0.001480875519825088, -0.003782867499688354, -0.004563197510918915, -0.003603347761256062, -0.001343627485716105, 0.001311870668104864, 0.003353808433641618, 0.004048631035069645, 0.003199227230106886, 0.001193704618627451, -0.001166186718647687, -0.002983013419355117, -0.003602853637616180, -0.002848310112984477, -0.001063226508100096, 0.001039123949022342, 0.002658942882507037, 0.003212474660183158, 0.002540416507340937, 0.000948535908910334, -0.000927239418214087, -0.002373103868945933, -0.002867594387946212, -0.002267987501713681, -0.000846905661554407, 0.000827955170450991, 0.002119111609339397, 0.002560741400051443, 0.002025296590730711, 0.000756262052132311, -0.000739303855389062, -0.001892076412474446, -0.002286174091331370, -0.001807928279099842, -0.000675000854171952, 0.000659758628755083, 0.001688191466843147, 0.002039408598203782, 0.001612423879409072, 0.000601861734148811, -0.000588116453682279, -0.001504448704003315, -0.001816891882241582, -0.001436035116324803, -0.000535840498947298, 0.000523416213624876, 0.001338438585676841, 0.001615770431422777, 0.001276549101858993, 0.000476126518877273, -0.000464880095884493, -0.001188206254554098, -0.001433723472939838, -0.001132161679039410, -0.000422057286948644, 0.000411870882593800, 0.001052146375983091, 0.001268840651620333, 0.001001384238134862, 0.000373084883642611, -0.000363860336052400, -0.000928925065719997, -0.001119530952228397, -0.000882974137750482, -0.000328750867302930, 0.000320405463014221, 0.000817421119396032, 0.000984453961140010, 0.000775882059036252, 0.000288667228263288, -0.000281130467306443, -0.000716681220662349, -0.000862467356249743, -0.000679211697876362, -0.000252501774287306, 0.000245712871528700, 0.000625885423905103, 0.000752586358514760, 0.000592188576464862, 0.000219966800262899, -0.000213872736947355, -0.000544320292542225, -0.000653952119299684, -0.000514135684863864, -0.000190810223851526, 0.000185364215425929, 0.000471357813848761, 0.000565806866512189, 0.000444454300857244, 0.000164808595136697, -0.000159968877679458, -0.000406438723822314, -0.000487474222275292, -0.000382608780796951, -0.000141761546497089, 0.000137490409632074, 0.000349059235836180, 0.000418343520512935, 0.000328114428169049, 0.000121487361009229, -0.000117750373436348, -0.000298760423406515, -0.000357857249612805, -0.000280527771406576, -0.000103819418115250, 0.000100584805088331, 0.000255119692416442, 0.000305500959846105, 0.000239438745337938, 0.000088603333694827, -0.000085841475427806, -0.000217743913088988, -0.000260795132031892, -0.000204464389965927, -0.000075694654555456, 0.000073377681668811, 0.000186263881482954, 0.000223288619765818, 0.000175243768580115, 0.000064956999153449, -0.000063058466593141, -0.000160329854353107, -0.000192553363937692, -0.000151433873201800, -0.000056260560166241, 0.000054755185033601, 0.000139607956874713, 0.000168180143307320, 0.000132706335130022, 0.000049480902522150, -0.000048344354295482, -0.000123777304921940, -0.000149775174295489, -0.000118744796208458, -0.000044498004194751, 0.000043706738152633, 0.000112527715832246, 0.000136957410949681, 0.000109242825450937, 0.000041195497588765, -0.000040726624041752, -0.000105557906420185, -0.000129356425201160, -0.000103902288077706, -0.000039460077482133]'
    comment: FIR Orden400 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '80000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000031549667479784, -0.000082968289670589, -0.000103109540693622, -0.000083946286929727, -0.000032297511785033, 0.000032561612890548, 0.000086021515852756, 0.000107388669575028, 0.000087821596665204, 0.000033937486163914, -0.000034363156506491, -0.000091165824926709, -0.000114282155368686, -0.000093836032334673, -0.000036403762053292, 0.000037000266071175, 0.000098522026252410, 0.000123939915135279, 0.000102111367869293, 0.000039743044487071, -0.000040519843318527, -0.000108213439258483, -0.000136515052289313, -0.000112772025740142, -0.000044003078337510, 0.000044969859212631, 0.000120366262852294, 0.000152164332741068, 0.000125945478425732, 0.000049232808056091, -0.000050399520271394, -0.000135110028605865, -0.000171048767651666, -0.000141762738689223, -0.000055482572346151, 0.000056859470865357, 0.000152578150949571, 0.000193334319704960, 0.000160358952801891, 0.000062804339350337, -0.000064402037265328, -0.000172908590008950, -0.000219192752891111, -0.000181874113452227, -0.000071251988970696, 0.000073081520290032, 0.000196244645657305, 0.000248802649578240, 0.000206453912266873, 0.000080881650207469, -0.000082954544726473, -0.000222735904963220, -0.000282350623295843, -0.000234250755789822, -0.000091752102964453, 0.000094080475324737, 0.000252539369661354, 0.000320032761392307, 0.000265424973611989, 0.000103925255700681, -0.000106521911186409, -0.000285820795790608, -0.000362056338850552, -0.000300146253362696, -0.000117466712711080, 0.000120345272876866, 0.000322756284517457, 0.000408641853430230, 0.000338595344792236, 0.000132446447822640, -0.000135621499735389, -0.000363534171774657, -0.000460025443449091, -0.000380966084614963, -0.000148939605069070, 0.000152426878812642, 0.000408357275198426, 0.000516461763575878, 0.000427467805706726, 0.000167027451683042, -0.000170844031874894, -0.000457445570605640, -0.000578227411853362, -0.000478328209405087, -0.000186798514822539, 0.000190963093296618, 0.000511039387806032, 0.000645625023968528, 0.000533796799046624, 0.000208349941232804, -0.000212883119849977, -0.000569403238090028, -0.000718988180110270, -0.000594148997844540, -0.000231789129086272, 0.000236713783974281, 0.000632830414897847, 0.000798687307743062, 0.000659691106605448, 0.000257235694290495, -0.000262577415870263, -0.000701648547188366, -0.000885136813215798, -0.000730766299140848, -0.000284823850640533, 0.000290611477815527, 0.000776226334970941, 0.000978803740389864, 0.000807761909067918, 0.000314705305756356, -0.000320971577976390, -0.000856981762647243, -0.001080218341109701, -0.000891118335953516, -0.000347052804807416, 0.000353835162864668, 0.000944392174316290, 0.001189987058418921, 0.000981339998439598, 0.000382064494460181, -0.000389406070541364, -0.001039006714709399, -0.001308808580491060, -0.001079008897147665, -0.000419969334420721, 0.000427920185154438, 0.001141461802497596, 0.001437493838025774, 0.001184801535392384, 0.000461033859402827, -0.000469652513911207, -0.001252500527732060, -0.001576991114918837, -0.001299510202532288, -0.000505570699214843, 0.000514926119749416, 0.001372997179427130, 0.001728417857914877, 0.001424069985239174, 0.000553949412233008, -0.000564123501234285, -0.001503988553894085, -0.001893101360971384, -0.001559593384744037, -0.000606610398055576, 0.000617701237631933, 0.001646714332354941, 0.002072631349137342, 0.001707415158250078, 0.000664082959932382, -0.000676209045940430, -0.001802669745740321, -0.002268928727728479, -0.001869151087995533, -0.000727009035993722, 0.000740314882085564, 0.001973675121263707, 0.002484336607303667, 0.002046776000510235, 0.000796174789717080, -0.000810838447989873, -0.002161968982082561, -0.002721742508409372, -0.002242728819979373, -0.000872553274867888, 0.000888796584225507, 0.002370334567287298, 0.002984744967254934, 0.002460056260056760, 0.000957362987824466, -0.000975465778803386, -0.002602274667472895, -0.003277884587464172, -0.002702612826232501, -0.001052149670137805, 0.001072469831056101, 0.002862257777561620, 0.003606970642636099, 0.002975344687519068, 0.001158902901745538, -0.001181905336380929, -0.003156072000364570, -0.003979552767123606, -0.003284701553122390, -0.001280226072926125, 0.001306525512429525, 0.003491346084826310, 0.004405618976673624, 0.003639249396136409, 0.001419590612818728, -0.001450016682787193, -0.003878337587578252, -0.004898657776850196, -0.004050608436178148, -0.001581727606741640, 0.001617426920389513, 0.004331162904605001, 0.005477327075998616, 0.004534937423849356, 0.001773252019616343, -0.001815854435695542, -0.004869788041296525, -0.006168177013070176, -0.005115375414747850, -0.002003698450495706, 0.002055600000442083, 0.005523392201830393, 0.007010294620939113, 0.005826248546772901, 0.002287324059440188, -0.002352194574796914, -0.006336352207645922, -0.008063664028571890, -0.006720734281642315, -0.002646435030755400, 0.002730190022287956, 0.007379585916361401, 0.009425243541190469, 0.007885824729000691, 0.003117984889704170, -0.003230804708213020, -0.008773835860836980, -0.011262581068316941, -0.009474229341667539, -0.003767935448389101, 0.003928930954280798, 0.010742676405235839, 0.013892249761877997, 0.011780792692307730, 0.004726633646139758, -0.004976307677097069, -0.013751478087906313, -0.017992744270507555, -0.015457853250138688, -0.006292659525444859, 0.006734015546018996, 0.018955181103838713, 0.025328327318478078, 0.022292407056419876, 0.009333382456083620, -0.010323377620248981, -0.030226444954448355, -0.042368261433849377, -0.039570179578614396, -0.017870368995883009, 0.021849530292925197, 0.073567935903298604, 0.127336817857710199, 0.171721129838928288, 0.196789256872273333, 0.196789256872273333, 0.171721129838928288, 0.127336817857710199, 0.073567935903298604, 0.021849530292925197, -0.017870368995883009, -0.039570179578614396, -0.042368261433849377, -0.030226444954448355, -0.010323377620248981, 0.009333382456083620, 0.022292407056419876, 0.025328327318478078, 0.018955181103838713, 0.006734015546018996, -0.006292659525444859, -0.015457853250138688, -0.017992744270507555, -0.013751478087906313, -0.004976307677097069, 0.004726633646139758, 0.011780792692307730, 0.013892249761877997, 0.010742676405235839, 0.003928930954280798, -0.003767935448389101, -0.009474229341667539, -0.011262581068316941, -0.008773835860836980, -0.003230804708213020, 0.003117984889704170, 0.007885824729000691, 0.009425243541190469, 0.007379585916361401, 0.002730190022287956, -0.002646435030755400, -0.006720734281642315, -0.008063664028571890, -0.006336352207645922, -0.002352194574796914, 0.002287324059440188, 0.005826248546772901, 0.007010294620939113, 0.005523392201830393, 0.002055600000442083, -0.002003698450495706, -0.005115375414747850, -0.006168177013070176, -0.004869788041296525, -0.001815854435695542, 0.001773252019616343, 0.004534937423849356, 0.005477327075998616, 0.004331162904605001, 0.001617426920389513, -0.001581727606741640, -0.004050608436178148, -0.004898657776850196, -0.003878337587578252, -0.001450016682787193, 0.001419590612818728, 0.003639249396136409, 0.004405618976673624, 0.003491346084826310, 0.001306525512429525, -0.001280226072926125, -0.003284701553122390, -0.003979552767123606, -0.003156072000364570, -0.001181905336380929, 0.001158902901745538, 0.002975344687519068, 0.003606970642636099, 0.002862257777561620, 0.001072469831056101, -0.001052149670137805, -0.002702612826232501, -0.003277884587464172, -0.002602274667472895, -0.000975465778803386, 0.000957362987824466, 0.002460056260056760, 0.002984744967254934, 0.002370334567287298, 0.000888796584225507, -0.000872553274867888, -0.002242728819979373, -0.002721742508409372, -0.002161968982082561, -0.000810838447989873, 0.000796174789717080, 0.002046776000510235, 0.002484336607303667, 0.001973675121263707, 0.000740314882085564, -0.000727009035993722, -0.001869151087995533, -0.002268928727728479, -0.001802669745740321, -0.000676209045940430, 0.000664082959932382, 0.001707415158250078, 0.002072631349137342, 0.001646714332354941, 0.000617701237631933, -0.000606610398055576, -0.001559593384744037, -0.001893101360971384, -0.001503988553894085, -0.000564123501234285, 0.000553949412233008, 0.001424069985239174, 0.001728417857914877, 0.001372997179427130, 0.000514926119749416, -0.000505570699214843, -0.001299510202532288, -0.001576991114918837, -0.001252500527732060, -0.000469652513911207, 0.000461033859402827, 0.001184801535392384, 0.001437493838025774, 0.001141461802497596, 0.000427920185154438, -0.000419969334420721, -0.001079008897147665, -0.001308808580491060, -0.001039006714709399, -0.000389406070541364, 0.000382064494460181, 0.000981339998439598, 0.001189987058418921, 0.000944392174316290, 0.000353835162864668, -0.000347052804807416, -0.000891118335953516, -0.001080218341109701, -0.000856981762647243, -0.000320971577976390, 0.000314705305756356, 0.000807761909067918, 0.000978803740389864, 0.000776226334970941, 0.000290611477815527, -0.000284823850640533, -0.000730766299140848, -0.000885136813215798, -0.000701648547188366, -0.000262577415870263, 0.000257235694290495, 0.000659691106605448, 0.000798687307743062, 0.000632830414897847, 0.000236713783974281, -0.000231789129086272, -0.000594148997844540, -0.000718988180110270, -0.000569403238090028, -0.000212883119849977, 0.000208349941232804, 0.000533796799046624, 0.000645625023968528, 0.000511039387806032, 0.000190963093296618, -0.000186798514822539, -0.000478328209405087, -0.000578227411853362, -0.000457445570605640, -0.000170844031874894, 0.000167027451683042, 0.000427467805706726, 0.000516461763575878, 0.000408357275198426, 0.000152426878812642, -0.000148939605069070, -0.000380966084614963, -0.000460025443449091, -0.000363534171774657, -0.000135621499735389, 0.000132446447822640, 0.000338595344792236, 0.000408641853430230, 0.000322756284517457, 0.000120345272876866, -0.000117466712711080, -0.000300146253362696, -0.000362056338850552, -0.000285820795790608, -0.000106521911186409, 0.000103925255700681, 0.000265424973611989, 0.000320032761392307, 0.000252539369661354, 0.000094080475324737, -0.000091752102964453, -0.000234250755789822, -0.000282350623295843, -0.000222735904963220, -0.000082954544726473, 0.000080881650207469, 0.000206453912266873, 0.000248802649578240, 0.000196244645657305, 0.000073081520290032, -0.000071251988970696, -0.000181874113452227, -0.000219192752891111, -0.000172908590008950, -0.000064402037265328, 0.000062804339350337, 0.000160358952801891, 0.000193334319704960, 0.000152578150949571, 0.000056859470865357, -0.000055482572346151, -0.000141762738689223, -0.000171048767651666, -0.000135110028605865, -0.000050399520271394, 0.000049232808056091, 0.000125945478425732, 0.000152164332741068, 0.000120366262852294, 0.000044969859212631, -0.000044003078337510, -0.000112772025740142, -0.000136515052289313, -0.000108213439258483, -0.000040519843318527, 0.000039743044487071, 0.000102111367869293, 0.000123939915135279, 0.000098522026252410, 0.000037000266071175, -0.000036403762053292, -0.000093836032334673, -0.000114282155368686, -0.000091165824926709, -0.000034363156506491, 0.000033937486163914, 0.000087821596665204, 0.000107388669575028, 0.000086021515852756, 0.000032561612890548, -0.000032297511785033, -0.000083946286929727, -0.000103109540693622, -0.000082968289670589, -0.000031549667479784]'
    comment: FIR Orden500 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000026281174987923, -0.000069057349908909, -0.000085727750699759, -0.000069699034556845, -0.000026771725206856, 0.000026938694951021, 0.000071010889154731, 0.000088432203605750, 0.000072123678169403, 0.000027789142012981, -0.000028048275569496, -0.000074159403794901, -0.000092627941885642, -0.000075766332076331, -0.000029276217105242, 0.000029631948251626, 0.000078560752839314, 0.000098386710321041, 0.000080685226612026, 0.000031255265671194, -0.000031712102949505, -0.000084273753987031, -0.000105781464375828, -0.000086939593129233, -0.000033748993793044, 0.000034311529363004, 0.000091358295508759, 0.000114886513565671, 0.000094589784192751, 0.000036780546002838, -0.000037453466180271, -0.000099875469679853, -0.000125777692113671, -0.000103697416386576, -0.000040373561686461, 0.000041161659384039, 0.000109887730531788, 0.000138532560406667, 0.000114325538655722, 0.000044552241483045, -0.000045460430802125, -0.000121459079092747, -0.000153230641281024, -0.000126538829533791, -0.000049341424995916, 0.000050374758255666, 0.000134655279762480, 0.000169953695773076, 0.000140403827114555, 0.000054766681331672, -0.000055930368865932, -0.000149544112027541, -0.000188786043686579, -0.000155989196226067, -0.000060854414221110, 0.000062153847325985, 0.000166195662388100, 0.000209814935180400, 0.000173366037978408, 0.000067631983757482, -0.000069072761235179, -0.000184682662158552, -0.000233130980592524, -0.000192608247704921, -0.000075127847123613, 0.000076715805942622, 0.000205080877748586, 0.000258828646926184, 0.000213792928331464, 0.000083371721081019, -0.000085112971762329, -0.000227469561162200, -0.000287006830873922, -0.000237000867424863, -0.000092394769476381, 0.000094295736922964, 0.000251931969811823, 0.000317769519999664, 0.000262317087636910, 0.000102229819601934, -0.000104297290218751, -0.000278555966385195, -0.000351226555805297, -0.000289831482030589, -0.000112911611948661, 0.000115152788058036, 0.000307434711489858, 0.000387494514961933, 0.000319639547923349, 0.000124477088744885, -0.000126899651493767, -0.000338667464217519, -0.000426697728095024, -0.000351843235499912, -0.000136965727713233, 0.000139577909903553, 0.000372360508723705, 0.000468969459313842, 0.000386551930650208, 0.000150419928753582, -0.000153230599314854, -0.000408628228541780, -0.000514453274344973, -0.000423883595426267, -0.000164885462828513, 0.000167904225007100, 0.000447594354818701, 0.000563304630891901, 0.000463966094377159, 0.000180411994267101, -0.000183649300047709, -0.000489393420195897, -0.000615692731989988, -0.000506938741061353, -0.000197053690113941, 0.000200520973938023, 0.000534172456954235, 0.000671802692037803, 0.000552954106575891, 0.000214869933162888, -0.000218579768698001, -0.000582092986677396, -0.000731838076358777, -0.000602180141405565, -0.000233926159100359, 0.000237892443682804, 0.000633333359565302, 0.000796023889237195, 0.000654802673844420, 0.000254294842968854, -0.000258533015444261, -0.000688091515312853, -0.000864610103250279, -0.000711028363422160, -0.000276056666248526, 0.000280583965342159, 0.000746588255049058, 0.000937875845549251, 0.000771088207180550, 0.000299301903649952, -0.000304137675807557, -0.000809071136404172, -0.001016134386099088, -0.000835241721641045, -0.000324132078762461, 0.000329298146745347, 0.000875819132965211, 0.001099739110909088, 0.000903781955728385, 0.000350661950760770, -0.000356183057335745, -0.000947148237420874, -0.001189090712911656, -0.000977041532299406, -0.000379021911469738, 0.000384926256556625, 0.001023418237669778, 0.001284645898446216, 0.001055399971793584, 0.000409360894661932, -0.000415680789638047, -0.001105040961377420, -0.001386927993978593, -0.001139292625808552, -0.000441849929534593, 0.000448622599544168, 0.001192490373000635, 0.001496539953799222, 0.001229221648114813, 0.000476686510756498, -0.000483955085541010, -0.001286315026837511, -0.001614180426540991, -0.001325769565808353, -0.000514100012420776, 0.000521914759403121, 0.001387153542760369, 0.001740663753167957, 0.001429616198554984, 0.000554358448706668, -0.000562778320333582, -0.001495753996327860, -0.001876945066168010, -0.001541559930696851, -0.000597776988922545, 0.000606871581841773, 0.001612998429236993, 0.002024152075601088, 0.001662544701458339, 0.000644728782181807, -0.000654580842090425, -0.001739934130683047, -0.002183625717682457, -0.001793694591269703, -0.000695658857490598, 0.000706367515646803, 0.001877813978114205, 0.002356972690649281, 0.001936358622351513, 0.000751102169822588, -0.000762787173398023, -0.002028149055224152, -0.002546134143609575, -0.002092169476968194, -0.000811707311172894, 0.000824514622802180, 0.002192778141670975, 0.002753476628733752, 0.002263121455763447, 0.000878268076973468, -0.000892377390120575, -0.002373960745646827, -0.002981914220497564, -0.002451675459856698, -0.000951766103005746, 0.000967401084229143, 0.002574503546209702, 0.003235075022683255, 0.002660902600630441, 0.001033429385544657, -0.001050871872365028, -0.002797935140057794, -0.003517532107492679, -0.002894684108599234, -0.001124814047280710, 0.001144424106426971, 0.003048752093427135, 0.003835129990145208, 0.003157995098899004, 0.001227920888918150, -0.001250165765015357, -0.003332772730906870, -0.004195456174037042, -0.003457316326960177, -0.001345365313639563, 0.001370862230799142, 0.003657658042196441, 0.004608539004074408, 0.003801246772758385, 0.001480631500705257, -0.001510212717509715, -0.004033699690317986, -0.005087909579015101, -0.004201441459123016, -0.001638463957657066, 0.001673278845699898, 0.004475049858915778, 0.005652270426785020, 0.004674095535297312, 0.001825491663379896, -0.001867172946559697, -0.005001711789891985, -0.006328218029158210, -0.005242385791414031, -0.002051263717400692, 0.002102210373609993, 0.005642903059299762, 0.007154887069534188, 0.005940677073937438, 0.002330052117401757, -0.002393936967792649, -0.006443039533504515, -0.008192310009713145, -0.006822185970960237, -0.002684177987805997, 0.002766919511993045, 0.007473078027806506, 0.009537493116743734, 0.007973943176288998, 0.003150609481195542, -0.003262390856580764, -0.008853798528092980, -0.011358029873658212, -0.009548694294583378, -0.003795321883059336, 0.003955256387992192, 0.010808808301142947, 0.013970532146138361, 0.011841313291524873, 0.004748672461203560, -0.004997264249985054, -0.013803498491162499, -0.018053514613697211, -0.015504149348464419, -0.006309242707983837, 0.006749493202203301, 0.018992792978608692, 0.025371201602065217, 0.022324147914422200, 0.009344372616737118, -0.010333223094164810, -0.030249187047805829, -0.042392560850213111, -0.039586683936230438, -0.017875427207901935, 0.021853274961005892, 0.073573973943211315, 0.127338741283617690, 0.171716058073096117, 0.196779052764500362, 0.196779052764500362, 0.171716058073096117, 0.127338741283617690, 0.073573973943211315, 0.021853274961005892, -0.017875427207901935, -0.039586683936230438, -0.042392560850213111, -0.030249187047805829, -0.010333223094164810, 0.009344372616737118, 0.022324147914422200, 0.025371201602065217, 0.018992792978608692, 0.006749493202203301, -0.006309242707983837, -0.015504149348464419, -0.018053514613697211, -0.013803498491162499, -0.004997264249985054, 0.004748672461203560, 0.011841313291524873, 0.013970532146138361, 0.010808808301142947, 0.003955256387992192, -0.003795321883059336, -0.009548694294583378, -0.011358029873658212, -0.008853798528092980, -0.003262390856580764, 0.003150609481195542, 0.007973943176288998, 0.009537493116743734, 0.007473078027806506, 0.002766919511993045, -0.002684177987805997, -0.006822185970960237, -0.008192310009713145, -0.006443039533504515, -0.002393936967792649, 0.002330052117401757, 0.005940677073937438, 0.007154887069534188, 0.005642903059299762, 0.002102210373609993, -0.002051263717400692, -0.005242385791414031, -0.006328218029158210, -0.005001711789891985, -0.001867172946559697, 0.001825491663379896, 0.004674095535297312, 0.005652270426785020, 0.004475049858915778, 0.001673278845699898, -0.001638463957657066, -0.004201441459123016, -0.005087909579015101, -0.004033699690317986, -0.001510212717509715, 0.001480631500705257, 0.003801246772758385, 0.004608539004074408, 0.003657658042196441, 0.001370862230799142, -0.001345365313639563, -0.003457316326960177, -0.004195456174037042, -0.003332772730906870, -0.001250165765015357, 0.001227920888918150, 0.003157995098899004, 0.003835129990145208, 0.003048752093427135, 0.001144424106426971, -0.001124814047280710, -0.002894684108599234, -0.003517532107492679, -0.002797935140057794, -0.001050871872365028, 0.001033429385544657, 0.002660902600630441, 0.003235075022683255, 0.002574503546209702, 0.000967401084229143, -0.000951766103005746, -0.002451675459856698, -0.002981914220497564, -0.002373960745646827, -0.000892377390120575, 0.000878268076973468, 0.002263121455763447, 0.002753476628733752, 0.002192778141670975, 0.000824514622802180, -0.000811707311172894, -0.002092169476968194, -0.002546134143609575, -0.002028149055224152, -0.000762787173398023, 0.000751102169822588, 0.001936358622351513, 0.002356972690649281, 0.001877813978114205, 0.000706367515646803, -0.000695658857490598, -0.001793694591269703, -0.002183625717682457, -0.001739934130683047, -0.000654580842090425, 0.000644728782181807, 0.001662544701458339, 0.002024152075601088, 0.001612998429236993, 0.000606871581841773, -0.000597776988922545, -0.001541559930696851, -0.001876945066168010, -0.001495753996327860, -0.000562778320333582, 0.000554358448706668, 0.001429616198554984, 0.001740663753167957, 0.001387153542760369, 0.000521914759403121, -0.000514100012420776, -0.001325769565808353, -0.001614180426540991, -0.001286315026837511, -0.000483955085541010, 0.000476686510756498, 0.001229221648114813, 0.001496539953799222, 0.001192490373000635, 0.000448622599544168, -0.000441849929534593, -0.001139292625808552, -0.001386927993978593, -0.001105040961377420, -0.000415680789638047, 0.000409360894661932, 0.001055399971793584, 0.001284645898446216, 0.001023418237669778, 0.000384926256556625, -0.000379021911469738, -0.000977041532299406, -0.001189090712911656, -0.000947148237420874, -0.000356183057335745, 0.000350661950760770, 0.000903781955728385, 0.001099739110909088, 0.000875819132965211, 0.000329298146745347, -0.000324132078762461, -0.000835241721641045, -0.001016134386099088, -0.000809071136404172, -0.000304137675807557, 0.000299301903649952, 0.000771088207180550, 0.000937875845549251, 0.000746588255049058, 0.000280583965342159, -0.000276056666248526, -0.000711028363422160, -0.000864610103250279, -0.000688091515312853, -0.000258533015444261, 0.000254294842968854, 0.000654802673844420, 0.000796023889237195, 0.000633333359565302, 0.000237892443682804, -0.000233926159100359, -0.000602180141405565, -0.000731838076358777, -0.000582092986677396, -0.000218579768698001, 0.000214869933162888, 0.000552954106575891, 0.000671802692037803, 0.000534172456954235, 0.000200520973938023, -0.000197053690113941, -0.000506938741061353, -0.000615692731989988, -0.000489393420195897, -0.000183649300047709, 0.000180411994267101, 0.000463966094377159, 0.000563304630891901, 0.000447594354818701, 0.000167904225007100, -0.000164885462828513, -0.000423883595426267, -0.000514453274344973, -0.000408628228541780, -0.000153230599314854, 0.000150419928753582, 0.000386551930650208, 0.000468969459313842, 0.000372360508723705, 0.000139577909903553, -0.000136965727713233, -0.000351843235499912, -0.000426697728095024, -0.000338667464217519, -0.000126899651493767, 0.000124477088744885, 0.000319639547923349, 0.000387494514961933, 0.000307434711489858, 0.000115152788058036, -0.000112911611948661, -0.000289831482030589, -0.000351226555805297, -0.000278555966385195, -0.000104297290218751, 0.000102229819601934, 0.000262317087636910, 0.000317769519999664, 0.000251931969811823, 0.000094295736922964, -0.000092394769476381, -0.000237000867424863, -0.000287006830873922, -0.000227469561162200, -0.000085112971762329, 0.000083371721081019, 0.000213792928331464, 0.000258828646926184, 0.000205080877748586, 0.000076715805942622, -0.000075127847123613, -0.000192608247704921, -0.000233130980592524, -0.000184682662158552, -0.000069072761235179, 0.000067631983757482, 0.000173366037978408, 0.000209814935180400, 0.000166195662388100, 0.000062153847325985, -0.000060854414221110, -0.000155989196226067, -0.000188786043686579, -0.000149544112027541, -0.000055930368865932, 0.000054766681331672, 0.000140403827114555, 0.000169953695773076, 0.000134655279762480, 0.000050374758255666, -0.000049341424995916, -0.000126538829533791, -0.000153230641281024, -0.000121459079092747, -0.000045460430802125, 0.000044552241483045, 0.000114325538655722, 0.000138532560406667, 0.000109887730531788, 0.000041161659384039, -0.000040373561686461, -0.000103697416386576, -0.000125777692113671, -0.000099875469679853, -0.000037453466180271, 0.000036780546002838, 0.000094589784192751, 0.000114886513565671, 0.000091358295508759, 0.000034311529363004, -0.000033748993793044, -0.000086939593129233, -0.000105781464375828, -0.000084273753987031, -0.000031712102949505, 0.000031255265671194, 0.000080685226612026, 0.000098386710321041, 0.000078560752839314, 0.000029631948251626, -0.000029276217105242, -0.000075766332076331, -0.000092627941885642, -0.000074159403794901, -0.000028048275569496, 0.000027789142012981, 0.000072123678169403, 0.000088432203605750, 0.000071010889154731, 0.000026938694951021, -0.000026771725206856, -0.000069699034556845, -0.000085727750699759, -0.000069057349908909, -0.000026281174987923]'
    comment: FIR Orden600 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '80000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000022520469821846, -0.000059142271073535, -0.000073365316636330, -0.000059594150366417, -0.000022865861723556, 0.000022979988842166, 0.000060490762470807, 0.000075213453061673, 0.000061237236958210, 0.000023550433788952, -0.000023722002106515, -0.000062585001289011, -0.000077991027344246, -0.000063638454145482, -0.000024526960204577, 0.000024758350262622, 0.000065456068007390, 0.000081736559240239, 0.000066829049168757, 0.000025807409049421, -0.000026101034674327, -0.000069135471340008, -0.000086489107380808, -0.000070840713206477, -0.000027403921118650, 0.000027762232669958, 0.000073655189456904, 0.000092288321864685, 0.000075705625277850, 0.000029328827221051, -0.000029754315378779, -0.000079047718120872, -0.000099174505575881, -0.000081456503350783, -0.000031594668285785, 0.000032089868435202, 0.000085346126488845, 0.000107188685173449, 0.000088126663438703, 0.000034214218584717, -0.000034781715864233, -0.000092584121417579, -0.000116372692815659, -0.000095750087565972, -0.000037200512414308, 0.000037842947500262, 0.000100796121217766, 0.000126769259813612, 0.000104361501592055, 0.000040566874624505, -0.000041286950336089, -0.000110017339920866, -0.000138422123562139, -0.000113996464011799, -0.000044326955431909, 0.000045127444250400, 0.000120283883261575, 0.000151376149272288, 0.000124691466996091, 0.000048494770012465, -0.000049378522621459, -0.000131632857739289, -0.000165677468233865, -0.000136484051107386, -0.000053084743435760, 0.000054054698403821, 0.000144102494307969, 0.000181373634573421, 0.000149412935322019, 0.000058111761580707, -0.000059170956324809, -0.000157732288459854, -0.000198513802748479, -0.000163518164220910, -0.000063591228763018, 0.000064742811950943, 0.000172563158720557, 0.000217148928339981, 0.000178841274478396, 0.000069539132910338, -0.000070786378483452, -0.000188637625867181, -0.000237331995080257, -0.000195425483092154, -0.000075972119244445, 0.000077318442269370, 0.000206000015525927, 0.000259118271493783, 0.000213315900164845, 0.000082907573575105, -0.000084356548164732, -0.000224696687210593, -0.000282565601045077, -0.000232559769480260, -0.000090363716480423, 0.000091919096062386, 0.000244776293340307, 0.000307734730297541, 0.000253206740626447, 0.000098359709850206, -0.000100025450105306, -0.000266290072338540, -0.000334689680307708, -0.000275309177021502, -0.000106915777506925, 0.000108696062352867, 0.000289292180583549, 0.000363498167333947, 0.000298922504913285, 0.000116053341901877, -0.000117952612960404, -0.000313840068774575, -0.000394232079955587, -0.000324105609276412, -0.000125795179221514, 0.000127818169281849, 0.000339994909226124, 0.000426968020912507, 0.000350921283548147, 0.000136165595641859, -0.000138317366723308, -0.000367822081737073, -0.000461787923429795, -0.000379436741365162, -0.000147190627952540, 0.000149476614676914, 0.000397391727044954, 0.000498779753541278, 0.000409724199932351, 0.000158898272354892, -0.000161324331469728, -0.000428779378520408, -0.000538038312037212, -0.000441861546429376, -0.000171318745942262, 0.000173891212993799, 0.000462066684748183, 0.000579666152220468, 0.000475933101013053, 0.000184484786226285, -0.000187210540573083, -0.000497342238063003, -0.000623774632770103, -0.000512030492596007, -0.000198431995114871, 0.000201318534708102, 0.000534702527066434, 0.000670485128818283, 0.000550253666789730, 0.000213199235024053, -0.000216254762668759, -0.000574253034779172, -0.000719930429021608, -0.000590712049343198, -0.000228829086376810, 0.000232062609543991, 0.000616109508556536, 0.000772256352176368, 0.000633525893278532, 0.000245368377682906, -0.000248789824384019, -0.000660399433435818, -0.000827623624080709, -0.000678827843970349, -0.000262868801806998, 0.000266489155591706, 0.000707263747484873, 0.000886210064264587, 0.000726764763960671, 0.000281387635046697, -0.000285219092874723, -0.000756858846361762, -0.000948213143387797, -0.000777499868770134, -0.000300988579429608, 0.000305044737035976, 0.000809358935177783, 0.001013852986202703, 0.000831215236920559, 0.000321742753426157, -0.000326038823902038, -0.000864958799544911, -0.001083375912862423, -0.000888114772569250, -0.000343729862364132, 0.000348282935082869, 0.000923877085273557, 0.001157058634192497, 0.000948427718572946, 0.000367039587628101, -0.000371868936455472, -0.000986360198764034, -0.001235213245906995, -0.001012412842800319, -0.000391773243779859, 0.000396900695850849, 0.001052686969332550, 0.001318193204778162, 0.001080363452940058, 0.000418045765796239, -0.000423496145197840, -0.001123174252757631, -0.001406400519399321, -0.001152613437440247, -0.000445988105719252, 0.000451789770441240, 0.001198183705309722, 0.001500294453485035, 0.001229544586085850, 0.000475750140589783, -0.000481935636442275, -0.001278130023741499, -0.001600402126329878, -0.001311595518010793, -0.000507504223609020, 0.000514111085954451, 0.001363491035252309, 0.001707331511162935, 0.001399272644654102, 0.000541449550916430, -0.000548521294731550, -0.001454820140980498, -0.001821787489233764, -0.001493163730354697, -0.000577817571318685, 0.000585404923319184, 0.001552761779676535, 0.001944591832274746, 0.001593954798533075, 0.000616878741770219, -0.000625041186601700, -0.001658070803245282, -0.002076708283062218, -0.001702451388220557, -0.000658951036273465, 0.000667758774344064, 0.001771636970103997, 0.002219274319708030, 0.001819605526155078, 0.000704410763442532, -0.000713947214231390, -0.001894516206898033, -0.002373641779325064, -0.001946550292429265, -0.000753706458495384, 0.000764071495325464, 0.002027970927015743, 0.002541429365752574, 0.002084644597777827, 0.000807376920225985, -0.000818691098671921, -0.002173522623669609, -0.002724591306936306, -0.002235531875819530, -0.000866074911909279, 0.000878485067186546, 0.002333021331907244, 0.002925508272153914, 0.002401218012515468, 0.000930598716457884, -0.000944285476396206, -0.002508738630476074, -0.003147109452522007, -0.002584176296280646, -0.001001934760864747, 0.001017122785521040, 0.002703494050132485, 0.003393039025056583, 0.002787490992292329, 0.001081316122503721, -0.001098288299075758, -0.002920829782563744, -0.003667887043944862, -0.003015057211767030, -0.001170304279574860, 0.001189421777322696, 0.003165256689779032, 0.003977515861279045, 0.003271864632744214, 0.001270905645170880, -0.001292636860297344, -0.003442608044419120, -0.004329531610491338, -0.003564409204296036, -0.001385741471459923, 0.001410704824223033, 0.003760560379771308, 0.004733981987031527, 0.003901305669794851, 0.001518301999078812, -0.001547330983306674, -0.004129421429182202, -0.005204418071846058, -0.004294225309944900, -0.001673337979163985, 0.001707583233762545, 0.004563359885761040, 0.005759562892251861, 0.004759379928224525, 0.001857484776587233, -0.001898580315186411, -0.005082395821253615, -0.006426033789234576, -0.005319963228426356, -0.002080297962818997, 0.002130644061152872, 0.005715763788180317, 0.007242986431100735, 0.006010357022880461, 0.002356056006532512, -0.002419326768520515, -0.006507896498566078, -0.008270474009394971, -0.006883794574193462, -0.002707086355279484, 0.002789201486813025, 0.007529766994524228, 0.009605522581873494, 0.008027322329372873, 0.003170363061697113, -0.003281506827533757, -0.008902169914107454, -0.011415743112556906, -0.009593699431867596, -0.003811866309237300, 0.003971152750209411, 0.010848723483002162, 0.014017759514582112, 0.011877808137664319, 0.004761955860718340, -0.005009889077985793, -0.013834820631556338, -0.018090084700493052, -0.015531992203849513, -0.006319209222854076, 0.006758788158608123, 0.019015360301927173, 0.025396899059643017, 0.022343147512679164, 0.009350940246287676, -0.010339093784936609, -0.030262706785821908, -0.042406942687618694, -0.039596384659369835, -0.017878364568260294, 0.021855396170650628, 0.073577157396414572, 0.127339113892111666, 0.171711942652135630, 0.196771690876976130, 0.196771690876976130, 0.171711942652135630, 0.127339113892111666, 0.073577157396414572, 0.021855396170650628, -0.017878364568260294, -0.039596384659369835, -0.042406942687618694, -0.030262706785821908, -0.010339093784936609, 0.009350940246287676, 0.022343147512679164, 0.025396899059643017, 0.019015360301927173, 0.006758788158608123, -0.006319209222854076, -0.015531992203849513, -0.018090084700493052, -0.013834820631556338, -0.005009889077985793, 0.004761955860718340, 0.011877808137664319, 0.014017759514582112, 0.010848723483002162, 0.003971152750209411, -0.003811866309237300, -0.009593699431867596, -0.011415743112556906, -0.008902169914107454, -0.003281506827533757, 0.003170363061697113, 0.008027322329372873, 0.009605522581873494, 0.007529766994524228, 0.002789201486813025, -0.002707086355279484, -0.006883794574193462, -0.008270474009394971, -0.006507896498566078, -0.002419326768520515, 0.002356056006532512, 0.006010357022880461, 0.007242986431100735, 0.005715763788180317, 0.002130644061152872, -0.002080297962818997, -0.005319963228426356, -0.006426033789234576, -0.005082395821253615, -0.001898580315186411, 0.001857484776587233, 0.004759379928224525, 0.005759562892251861, 0.004563359885761040, 0.001707583233762545, -0.001673337979163985, -0.004294225309944900, -0.005204418071846058, -0.004129421429182202, -0.001547330983306674, 0.001518301999078812, 0.003901305669794851, 0.004733981987031527, 0.003760560379771308, 0.001410704824223033, -0.001385741471459923, -0.003564409204296036, -0.004329531610491338, -0.003442608044419120, -0.001292636860297344, 0.001270905645170880, 0.003271864632744214, 0.003977515861279045, 0.003165256689779032, 0.001189421777322696, -0.001170304279574860, -0.003015057211767030, -0.003667887043944862, -0.002920829782563744, -0.001098288299075758, 0.001081316122503721, 0.002787490992292329, 0.003393039025056583, 0.002703494050132485, 0.001017122785521040, -0.001001934760864747, -0.002584176296280646, -0.003147109452522007, -0.002508738630476074, -0.000944285476396206, 0.000930598716457884, 0.002401218012515468, 0.002925508272153914, 0.002333021331907244, 0.000878485067186546, -0.000866074911909279, -0.002235531875819530, -0.002724591306936306, -0.002173522623669609, -0.000818691098671921, 0.000807376920225985, 0.002084644597777827, 0.002541429365752574, 0.002027970927015743, 0.000764071495325464, -0.000753706458495384, -0.001946550292429265, -0.002373641779325064, -0.001894516206898033, -0.000713947214231390, 0.000704410763442532, 0.001819605526155078, 0.002219274319708030, 0.001771636970103997, 0.000667758774344064, -0.000658951036273465, -0.001702451388220557, -0.002076708283062218, -0.001658070803245282, -0.000625041186601700, 0.000616878741770219, 0.001593954798533075, 0.001944591832274746, 0.001552761779676535, 0.000585404923319184, -0.000577817571318685, -0.001493163730354697, -0.001821787489233764, -0.001454820140980498, -0.000548521294731550, 0.000541449550916430, 0.001399272644654102, 0.001707331511162935, 0.001363491035252309, 0.000514111085954451, -0.000507504223609020, -0.001311595518010793, -0.001600402126329878, -0.001278130023741499, -0.000481935636442275, 0.000475750140589783, 0.001229544586085850, 0.001500294453485035, 0.001198183705309722, 0.000451789770441240, -0.000445988105719252, -0.001152613437440247, -0.001406400519399321, -0.001123174252757631, -0.000423496145197840, 0.000418045765796239, 0.001080363452940058, 0.001318193204778162, 0.001052686969332550, 0.000396900695850849, -0.000391773243779859, -0.001012412842800319, -0.001235213245906995, -0.000986360198764034, -0.000371868936455472, 0.000367039587628101, 0.000948427718572946, 0.001157058634192497, 0.000923877085273557, 0.000348282935082869, -0.000343729862364132, -0.000888114772569250, -0.001083375912862423, -0.000864958799544911, -0.000326038823902038, 0.000321742753426157, 0.000831215236920559, 0.001013852986202703, 0.000809358935177783, 0.000305044737035976, -0.000300988579429608, -0.000777499868770134, -0.000948213143387797, -0.000756858846361762, -0.000285219092874723, 0.000281387635046697, 0.000726764763960671, 0.000886210064264587, 0.000707263747484873, 0.000266489155591706, -0.000262868801806998, -0.000678827843970349, -0.000827623624080709, -0.000660399433435818, -0.000248789824384019, 0.000245368377682906, 0.000633525893278532, 0.000772256352176368, 0.000616109508556536, 0.000232062609543991, -0.000228829086376810, -0.000590712049343198, -0.000719930429021608, -0.000574253034779172, -0.000216254762668759, 0.000213199235024053, 0.000550253666789730, 0.000670485128818283, 0.000534702527066434, 0.000201318534708102, -0.000198431995114871, -0.000512030492596007, -0.000623774632770103, -0.000497342238063003, -0.000187210540573083, 0.000184484786226285, 0.000475933101013053, 0.000579666152220468, 0.000462066684748183, 0.000173891212993799, -0.000171318745942262, -0.000441861546429376, -0.000538038312037212, -0.000428779378520408, -0.000161324331469728, 0.000158898272354892, 0.000409724199932351, 0.000498779753541278, 0.000397391727044954, 0.000149476614676914, -0.000147190627952540, -0.000379436741365162, -0.000461787923429795, -0.000367822081737073, -0.000138317366723308, 0.000136165595641859, 0.000350921283548147, 0.000426968020912507, 0.000339994909226124, 0.000127818169281849, -0.000125795179221514, -0.000324105609276412, -0.000394232079955587, -0.000313840068774575, -0.000117952612960404, 0.000116053341901877, 0.000298922504913285, 0.000363498167333947, 0.000289292180583549, 0.000108696062352867, -0.000106915777506925, -0.000275309177021502, -0.000334689680307708, -0.000266290072338540, -0.000100025450105306, 0.000098359709850206, 0.000253206740626447, 0.000307734730297541, 0.000244776293340307, 0.000091919096062386, -0.000090363716480423, -0.000232559769480260, -0.000282565601045077, -0.000224696687210593, -0.000084356548164732, 0.000082907573575105, 0.000213315900164845, 0.000259118271493783, 0.000206000015525927, 0.000077318442269370, -0.000075972119244445, -0.000195425483092154, -0.000237331995080257, -0.000188637625867181, -0.000070786378483452, 0.000069539132910338, 0.000178841274478396, 0.000217148928339981, 0.000172563158720557, 0.000064742811950943, -0.000063591228763018, -0.000163518164220910, -0.000198513802748479, -0.000157732288459854, -0.000059170956324809, 0.000058111761580707, 0.000149412935322019, 0.000181373634573421, 0.000144102494307969, 0.000054054698403821, -0.000053084743435760, -0.000136484051107386, -0.000165677468233865, -0.000131632857739289, -0.000049378522621459, 0.000048494770012465, 0.000124691466996091, 0.000151376149272288, 0.000120283883261575, 0.000045127444250400, -0.000044326955431909, -0.000113996464011799, -0.000138422123562139, -0.000110017339920866, -0.000041286950336089, 0.000040566874624505, 0.000104361501592055, 0.000126769259813612, 0.000100796121217766, 0.000037842947500262, -0.000037200512414308, -0.000095750087565972, -0.000116372692815659, -0.000092584121417579, -0.000034781715864233, 0.000034214218584717, 0.000088126663438703, 0.000107188685173449, 0.000085346126488845, 0.000032089868435202, -0.000031594668285785, -0.000081456503350783, -0.000099174505575881, -0.000079047718120872, -0.000029754315378779, 0.000029328827221051, 0.000075705625277850, 0.000092288321864685, 0.000073655189456904, 0.000027762232669958, -0.000027403921118650, -0.000070840713206477, -0.000086489107380808, -0.000069135471340008, -0.000026101034674327, 0.000025807409049421, 0.000066829049168757, 0.000081736559240239, 0.000065456068007390, 0.000024758350262622, -0.000024526960204577, -0.000063638454145482, -0.000077991027344246, -0.000062585001289011, -0.000023722002106515, 0.000023550433788952, 0.000061237236958210, 0.000075213453061673, 0.000060490762470807, 0.000022979988842166, -0.000022865861723556, -0.000059594150366417, -0.000073365316636330, -0.000059142271073535, -0.000022520469821846]'
    comment: FIR Orden700 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '80000000'
    num_nodos: '3'
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000019701309650015, -0.000051717323473994, -0.000064121122713392, -0.000052052104807492, -0.000019957169205462, 0.000020039674542875, 0.000052700254077749, 0.000065456976702846, 0.000053231351071155, 0.000020445507106930, -0.000020566194464399, -0.000054179387432592, -0.000067410638720386, -0.000054914037037201, -0.000021127528663965, 0.000021287788013579, 0.000056172877596674, 0.000070004599755354, 0.000057118400454654, 0.000022010216423857, -0.000022211454336727, -0.000058699092708805, -0.000073261619494616, -0.000059862899850484, -0.000023100638598792, 0.000023344279618619, 0.000061776632475649, 0.000077204748558441, 0.000063166233029801, 0.000024405956330996, -0.000024693444549906, -0.000065424348260795, -0.000081857354010361, -0.000067047358272553, -0.000025933432006464, 0.000026266232862089, 0.000069661366019345, 0.000087243148448155, 0.000071525518480110, 0.000027690438715955, -0.000028070041030728, -0.000074507112347001, -0.000093386223015182, -0.000076620268551754, -0.000029684470972461, 0.000030112389258277, 0.000079981343941221, 0.000100311084707424, 0.000082351506301057, 0.000031923156805939, -0.000032400933859946, -0.000086104180804245, -0.000108042698392519, -0.000088739507256033, -0.000034414271369504, 0.000034943481189545, 0.000092896143554317, 0.000116606534003311, 0.000095804963725309, 0.000037165752206232, -0.000037748003257781, -0.000100378195252864, -0.000126028619420925, -0.000103569028556165, -0.000040185716342789, 0.000040822655212873, 0.000108571788202329, 0.000136335599622009, 0.000112053364059690, 0.000043482479395547, -0.000044175794873316, -0.000117498916222876, -0.000147554802732582, -0.000121280196634721, -0.000047064576896905, 0.000047816004525324, 0.000127182172977143, 0.000159714313708327, 0.000131272377686437, 0.000050940788074670, -0.000051752115223275, -0.000137644816981751, -0.000172843056449473, -0.000142053451508893, -0.000055120162346333, 0.000055993233861140, 0.000148910844023994, 0.000186970885259600, 0.000153647730884926, 0.000059612048822892, -0.000060548773316871, -0.000161005067793329, -0.000202128686673629, -0.000166080381253264, -0.000064426129154861, 0.000065428486010466, 0.000173953209642198, 0.000218348492813621, 0.000179377514403614, 0.000069572454096724, -0.000070642501261540, -0.000187781998511485, -0.000235663607584494, -0.000193566292788325, -0.000075061484216150, 0.000076201366883651, 0.000202519282195081, 0.000254108747199008, 0.000208675045686747, 0.000080904135232548, -0.000082116095512554, -0.000218194151279225, -0.000273720196726411, -0.000224733398629333, -0.000087111828536596, 0.000088398216234788, 0.000234837077278999, 0.000294535984596890, 0.000241772417686685, 0.000093696547520367, -0.000095059832163268, -0.000252480066711145, -0.000316596077270394, -0.000259824770459190, -0.000100670900438636, 0.000102113684700248, 0.000271156833095350, 0.000339942596600562, 0.000278924905871939, 0.000108048190627722, -0.000109573225337408, -0.000290902989171005, -0.000364620062800880, -0.000299109255193579, -0.000115842495032020, 0.000117452695970348, 0.000311756261962245, 0.000390675666361322, 0.000320416457066512, 0.000124068752134091, -0.000125767218855352, -0.000333756733729951, -0.000418159572781902, -0.000342887609768794, -0.000132742860554564, 0.000134532897512463, 0.000356947112327247, 0.000447125264600341, 0.000366566554438876, 0.000141881789790383, -0.000143766930087776, -0.000381373035039830, -0.000477629925912900, -0.000391500193598565, -0.000151503704798273, 0.000153487736934867, 0.000407083410661597, 0.000509734875443352, 0.000417738850026183, 0.000161628106413696, -0.000163715104468388, -0.000434130805351235, -0.000543506055233350, -0.000445336671885091, -0.000172275989933498, 0.000174470347692917, 0.000462571878764683, 0.000579014583242866, 0.000474352091032226, 0.000183470024593711, -0.000185776494228609, -0.000492467878093791, -0.000616337379605389, -0.000504848342652628, -0.000195234757158005, 0.000197658493157000, 0.000523885199006350, 0.000655557878033201, 0.000536894055836524, 0.000207596843415815, -0.000210143452616424, -0.000556896024128524, -0.000696766835980971, -0.000570563926491048, -0.000220585312093090, 0.000223260910808043, 0.000591579051703161, 0.000740063259736502, 0.000605939486132378, 0.000234231866534885, -0.000237043145963736, -0.000628020329480758, -0.000785555463723424, -0.000643109982727630, -0.000248571230561382, 0.000251525531912662, 0.000666314211858818, 0.000833362287109289, 0.000682173392964706, 0.000263641546175719, -0.000266746947213280, -0.000706564461914791, -0.000883614495489045, -0.000723237589272533, -0.000279484832373615, 0.000282750247456377, 0.000748885524452438, 0.000936456401183844, 0.000766421689785717, 0.000296147516245973, -0.000299582812372220, -0.000793404001723451, -0.000992047742850039, -0.000811857625493878, -0.000313681049979415, 0.000317297181895998, 0.000840260370388073, 0.001050565874012561, 0.000859691966362354, 0.000332142630374545, -0.000335951798501579, -0.000889610986919979, -0.001112208321317617, -0.000910088057680910, -0.000351596041289438, 0.000355611877079483, 0.000941630439544295, 0.001177195787397269, 0.000963228529852436, 0.000372112644204104, -0.000376350428657878, -0.000996514318587229, -0.001245775691123773, -0.001019318260019819, -0.000393772548191057, 0.000398249470659158, 0.001054482494701615, 0.001318226360869852, 0.001078587883347596, 0.000416665998374729, -0.000421401464584346, -0.001115783017010751, -0.001394862025754850, -0.001141297976776549, -0.000440895032015609, 0.000445911032604469, 0.001180696772410986, 0.001476038787885401, 0.001207744070497996, 0.000466575464415387, -0.000471897018312446, -0.001249543085318727, -0.001562161808230143, -0.001278262684783305, -0.000493839283937950, 0.000499494974952761, 0.001322686487124364, 0.001653694004072007, 0.001353238645674968, 0.000522837558017288, -0.000528860188336744, -0.001400544950829689, -0.001751166642658096, -0.001433114007334441, -0.000553743982095828, 0.000560171373535764, 0.001483599974880124, 0.001855192331781135, 0.001518399008553255, 0.000586759243880780, -0.000593635227407619, -0.001572409019741128, -0.001966481065122152, -0.001609685626116460, -0.000622116430250465, 0.000629492077504903, 0.001667620963863834, 0.002085860194988473, 0.001707664472956884, 0.000660087779607240, -0.000668022948432528, -0.001769995470715092, -0.002214299502151470, -0.001813146045844893, -0.000700993187338267, 0.000709558478886707, 0.001880427472797351, 0.002352942948387079, 0.001927087687807295, 0.000745211019617414, -0.000754490280866457, -0.001999978423167351, -0.002503149287318149, -0.002050628143221949, -0.000793192001296948, 0.000803285558959311, 0.002129916602844645, 0.002666544558176644, 0.002185132323615396, 0.000845477248415801, -0.000856506136407896, -0.002271769701800330, -0.002845090727977711, -0.002332249987388397, -0.000902721964239689, 0.000914833520045152, 0.002427394267773788, 0.003041176592140603, 0.002493993655594248, 0.000965726989095197, -0.000979102365611927, -0.002599068693665484, -0.003257739836756445, -0.002672843546998993, -0.001035481418945660, 0.001050345822849481, 0.002789619609828190, 0.003498433482413061, 0.002871891135647937, 0.001113221105147823, -0.001129857990399614, -0.003002596575009954, -0.003767856752674186, -0.003095039001214294, -0.001200510397468694, 0.001219281518617914, 0.003242518065153268, 0.004071881468579646, 0.003347284527882818, 0.001299358669509469, -0.001320733024658294, -0.003515225189454877, -0.004418123500982108, -0.003635131582416956, -0.001412390212495528, 0.001436986838052756, 0.003828402510755165, 0.004816640512908661, 0.003967203004929011, 0.001543098371630345, -0.001571751388781087, -0.004192365947041267, -0.005280993733495746, -0.004355178309434903, -0.001696237050891315, 0.001730097732941421, 0.004621292479855215, 0.005829916451001069, 0.004815277610380212, 0.001878444792050808, -0.001919147787997257, -0.005135210499157176, -0.006490036280835545, -0.005370702912786050, -0.002099280331105129, 0.002149226543489442, 0.005763362790803563, 0.007300519023110059, 0.006055844180931249, 0.002373025229799102, -0.002435889364642717, -0.006550190023373010, -0.008321427593006678, -0.006923942438766626, -0.002722009853392184, 0.002803712164190690, 0.007566672569278503, 0.009649796871380479, 0.008062051048225865, 0.003183210796831918, -0.003293935980903251, -0.008933611070479301, -0.011453244737435872, -0.009622934268094593, -0.003822609982552953, 0.003981472260018596, 0.010874626857539014, 0.014048397788634088, 0.011901475410384006, 0.004770567064289403, -0.005018070095311934, -0.013855108971343575, -0.018113761121963882, -0.015550008891670559, -0.006325654537467955, 0.006764794995259359, 0.019029932312586664, 0.025413475547994786, 0.022355388033307510, 0.009355164577980524, -0.010342861630343874, -0.030271357444711669, -0.042416103590144305, -0.039602519565476627, -0.017880198607899175, 0.021856684859023621, 0.073578928584069961, 0.127338847260821453, 0.171708587922973777, 0.196766130472257328, 0.196766130472257328, 0.171708587922973777, 0.127338847260821453, 0.073578928584069961, 0.021856684859023621, -0.017880198607899175, -0.039602519565476627, -0.042416103590144305, -0.030271357444711669, -0.010342861630343874, 0.009355164577980524, 0.022355388033307510, 0.025413475547994786, 0.019029932312586664, 0.006764794995259359, -0.006325654537467955, -0.015550008891670559, -0.018113761121963882, -0.013855108971343575, -0.005018070095311934, 0.004770567064289403, 0.011901475410384006, 0.014048397788634088, 0.010874626857539014, 0.003981472260018596, -0.003822609982552953, -0.009622934268094593, -0.011453244737435872, -0.008933611070479301, -0.003293935980903251, 0.003183210796831918, 0.008062051048225865, 0.009649796871380479, 0.007566672569278503, 0.002803712164190690, -0.002722009853392184, -0.006923942438766626, -0.008321427593006678, -0.006550190023373010, -0.002435889364642717, 0.002373025229799102, 0.006055844180931249, 0.007300519023110059, 0.005763362790803563, 0.002149226543489442, -0.002099280331105129, -0.005370702912786050, -0.006490036280835545, -0.005135210499157176, -0.001919147787997257, 0.001878444792050808, 0.004815277610380212, 0.005829916451001069, 0.004621292479855215, 0.001730097732941421, -0.001696237050891315, -0.004355178309434903, -0.005280993733495746, -0.004192365947041267, -0.001571751388781087, 0.001543098371630345, 0.003967203004929011, 0.004816640512908661, 0.003828402510755165, 0.001436986838052756, -0.001412390212495528, -0.003635131582416956, -0.004418123500982108, -0.003515225189454877, -0.001320733024658294, 0.001299358669509469, 0.003347284527882818, 0.004071881468579646, 0.003242518065153268, 0.001219281518617914, -0.001200510397468694, -0.003095039001214294, -0.003767856752674186, -0.003002596575009954, -0.001129857990399614, 0.001113221105147823, 0.002871891135647937, 0.003498433482413061, 0.002789619609828190, 0.001050345822849481, -0.001035481418945660, -0.002672843546998993, -0.003257739836756445, -0.002599068693665484, -0.000979102365611927, 0.000965726989095197, 0.002493993655594248, 0.003041176592140603, 0.002427394267773788, 0.000914833520045152, -0.000902721964239689, -0.002332249987388397, -0.002845090727977711, -0.002271769701800330, -0.000856506136407896, 0.000845477248415801, 0.002185132323615396, 0.002666544558176644, 0.002129916602844645, 0.000803285558959311, -0.000793192001296948, -0.002050628143221949, -0.002503149287318149, -0.001999978423167351, -0.000754490280866457, 0.000745211019617414, 0.001927087687807295, 0.002352942948387079, 0.001880427472797351, 0.000709558478886707, -0.000700993187338267, -0.001813146045844893, -0.002214299502151470, -0.001769995470715092, -0.000668022948432528, 0.000660087779607240, 0.001707664472956884, 0.002085860194988473, 0.001667620963863834, 0.000629492077504903, -0.000622116430250465, -0.001609685626116460, -0.001966481065122152, -0.001572409019741128, -0.000593635227407619, 0.000586759243880780, 0.001518399008553255, 0.001855192331781135, 0.001483599974880124, 0.000560171373535764, -0.000553743982095828, -0.001433114007334441, -0.001751166642658096, -0.001400544950829689, -0.000528860188336744, 0.000522837558017288, 0.001353238645674968, 0.001653694004072007, 0.001322686487124364, 0.000499494974952761, -0.000493839283937950, -0.001278262684783305, -0.001562161808230143, -0.001249543085318727, -0.000471897018312446, 0.000466575464415387, 0.001207744070497996, 0.001476038787885401, 0.001180696772410986, 0.000445911032604469, -0.000440895032015609, -0.001141297976776549, -0.001394862025754850, -0.001115783017010751, -0.000421401464584346, 0.000416665998374729, 0.001078587883347596, 0.001318226360869852, 0.001054482494701615, 0.000398249470659158, -0.000393772548191057, -0.001019318260019819, -0.001245775691123773, -0.000996514318587229, -0.000376350428657878, 0.000372112644204104, 0.000963228529852436, 0.001177195787397269, 0.000941630439544295, 0.000355611877079483, -0.000351596041289438, -0.000910088057680910, -0.001112208321317617, -0.000889610986919979, -0.000335951798501579, 0.000332142630374545, 0.000859691966362354, 0.001050565874012561, 0.000840260370388073, 0.000317297181895998, -0.000313681049979415, -0.000811857625493878, -0.000992047742850039, -0.000793404001723451, -0.000299582812372220, 0.000296147516245973, 0.000766421689785717, 0.000936456401183844, 0.000748885524452438, 0.000282750247456377, -0.000279484832373615, -0.000723237589272533, -0.000883614495489045, -0.000706564461914791, -0.000266746947213280, 0.000263641546175719, 0.000682173392964706, 0.000833362287109289, 0.000666314211858818, 0.000251525531912662, -0.000248571230561382, -0.000643109982727630, -0.000785555463723424, -0.000628020329480758, -0.000237043145963736, 0.000234231866534885, 0.000605939486132378, 0.000740063259736502, 0.000591579051703161, 0.000223260910808043, -0.000220585312093090, -0.000570563926491048, -0.000696766835980971, -0.000556896024128524, -0.000210143452616424, 0.000207596843415815, 0.000536894055836524, 0.000655557878033201, 0.000523885199006350, 0.000197658493157000, -0.000195234757158005, -0.000504848342652628, -0.000616337379605389, -0.000492467878093791, -0.000185776494228609, 0.000183470024593711, 0.000474352091032226, 0.000579014583242866, 0.000462571878764683, 0.000174470347692917, -0.000172275989933498, -0.000445336671885091, -0.000543506055233350, -0.000434130805351235, -0.000163715104468388, 0.000161628106413696, 0.000417738850026183, 0.000509734875443352, 0.000407083410661597, 0.000153487736934867, -0.000151503704798273, -0.000391500193598565, -0.000477629925912900, -0.000381373035039830, -0.000143766930087776, 0.000141881789790383, 0.000366566554438876, 0.000447125264600341, 0.000356947112327247, 0.000134532897512463, -0.000132742860554564, -0.000342887609768794, -0.000418159572781902, -0.000333756733729951, -0.000125767218855352, 0.000124068752134091, 0.000320416457066512, 0.000390675666361322, 0.000311756261962245, 0.000117452695970348, -0.000115842495032020, -0.000299109255193579, -0.000364620062800880, -0.000290902989171005, -0.000109573225337408, 0.000108048190627722, 0.000278924905871939, 0.000339942596600562, 0.000271156833095350, 0.000102113684700248, -0.000100670900438636, -0.000259824770459190, -0.000316596077270394, -0.000252480066711145, -0.000095059832163268, 0.000093696547520367, 0.000241772417686685, 0.000294535984596890, 0.000234837077278999, 0.000088398216234788, -0.000087111828536596, -0.000224733398629333, -0.000273720196726411, -0.000218194151279225, -0.000082116095512554, 0.000080904135232548, 0.000208675045686747, 0.000254108747199008, 0.000202519282195081, 0.000076201366883651, -0.000075061484216150, -0.000193566292788325, -0.000235663607584494, -0.000187781998511485, -0.000070642501261540, 0.000069572454096724, 0.000179377514403614, 0.000218348492813621, 0.000173953209642198, 0.000065428486010466, -0.000064426129154861, -0.000166080381253264, -0.000202128686673629, -0.000161005067793329, -0.000060548773316871, 0.000059612048822892, 0.000153647730884926, 0.000186970885259600, 0.000148910844023994, 0.000055993233861140, -0.000055120162346333, -0.000142053451508893, -0.000172843056449473, -0.000137644816981751, -0.000051752115223275, 0.000050940788074670, 0.000131272377686437, 0.000159714313708327, 0.000127182172977143, 0.000047816004525324, -0.000047064576896905, -0.000121280196634721, -0.000147554802732582, -0.000117498916222876, -0.000044175794873316, 0.000043482479395547, 0.000112053364059690, 0.000136335599622009, 0.000108571788202329, 0.000040822655212873, -0.000040185716342789, -0.000103569028556165, -0.000126028619420925, -0.000100378195252864, -0.000037748003257781, 0.000037165752206232, 0.000095804963725309, 0.000116606534003311, 0.000092896143554317, 0.000034943481189545, -0.000034414271369504, -0.000088739507256033, -0.000108042698392519, -0.000086104180804245, -0.000032400933859946, 0.000031923156805939, 0.000082351506301057, 0.000100311084707424, 0.000079981343941221, 0.000030112389258277, -0.000029684470972461, -0.000076620268551754, -0.000093386223015182, -0.000074507112347001, -0.000028070041030728, 0.000027690438715955, 0.000071525518480110, 0.000087243148448155, 0.000069661366019345, 0.000026266232862089, -0.000025933432006464, -0.000067047358272553, -0.000081857354010361, -0.000065424348260795, -0.000024693444549906, 0.000024405956330996, 0.000063166233029801, 0.000077204748558441, 0.000061776632475649, 0.000023344279618619, -0.000023100638598792, -0.000059862899850484, -0.000073261619494616, -0.000058699092708805, -0.000022211454336727, 0.000022010216423857, 0.000057118400454654, 0.000070004599755354, 0.000056172877596674, 0.000021287788013579, -0.000021127528663965, -0.000054914037037201, -0.000067410638720386, -0.000054179387432592, -0.000020566194464399, 0.000020445507106930, 0.000053231351071155, 0.000065456976702846, 0.000052700254077749, 0.000020039674542875, -0.000019957169205462, -0.000052052104807492, -0.000064121122713392, -0.000051717323473994, -0.000019701309650015]'
    comment: FIR Orden800 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '10000000'
    num_nodos: '15'
  states: {}
- name: customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0_0_0
  id: customModule_filtro_FIR_cluster_log
  parameters:
    coef: '[-0.000017509440331449, -0.000045948969914073, -0.000056946947090992, -0.000046206633297888, -0.000017706345851678, 0.000017768555942912, 0.000046695327408244, 0.000057954081955340, 0.000047090302808154, 0.000018070359164356, -0.000018159222848913, -0.000047788337842442, -0.000059392486483909, -0.000048325132775929, -0.000018569367250878, 0.000018685749676130, 0.000049239303749143, 0.000061276159422002, 0.000049922471411311, 0.000019207713638604, -0.000019352488968303, -0.000051059644162361, -0.000063619245454336, -0.000051893786599226, -0.000019989788196632, 0.000020163840257280, 0.000053260902868175, 0.000066436045667542, 0.000054250674580962, 0.000020920030536147, -0.000021124253548985, -0.000055854757758885, -0.000069741029398566, -0.000057004869774847, -0.000022002933852834, 0.000022238233258526, 0.000058853031381882, 0.000073548847583519, 0.000060168255830309, 0.000023243049247959, -0.000023510342631729, -0.000062267702782540, -0.000077874347731920, -0.000063752878018231, -0.000024644990568200, 0.000024945208693802, 0.000066110920749712, 0.000082732590662958, 0.000067770957070145, 0.000026213439807925, -0.000026547527769762, -0.000070395018582609, -0.000088138869153311, -0.000072234904589436, -0.000027953153121900, 0.000028322071625328, 0.000075132530509312, 0.000094108728660510, 0.000077157340169789, 0.000029868967500983, -0.000030273694282020, -0.000080336209899882, -0.000100657990301960, -0.000082551110369302, -0.000031965808168663, 0.000032407339565279, 0.000086019049431325, 0.000107802776287760, 0.000088429309703752, 0.000034248696762069, -0.000034728049450568, -0.000092194303377636, -0.000115559538025647, -0.000094805303839106, -0.000036722760367577, 0.000037240973278969, 0.000098875512216028, 0.000123945087139036, 0.000101692755182138, 0.000039393241488579, -0.000039951377921370, -0.000106076529760534, -0.000132976629664550, -0.000109105651089117, -0.000042265509031110, 0.000042864658978746, 0.000113811553056839, 0.000142671803724017, 0.000117058334936164, 0.000045345070402292, -0.000045986353115494, -0.000122095155297502, -0.000153048720998143, -0.000125565540321545, -0.000048637584827121, 0.000049322151633496, 0.000130942322045582, 0.000164126012365372, 0.000134642428700383, 0.000052148878000716, -0.000052877915406734, -0.000140368491086957, -0.000175922878110533, -0.000144304630786221, -0.000055884958206672, 0.000056659691309778, 0.000150389596268351, 0.000188459143154331, 0.000154568292092430, 0.000059852034047139, -0.000060673730289170, -0.000161022115719702, -0.000201755317807412, -0.000165450123030260, -0.000064056533947356, 0.000064926507244072, 0.000172283124906551, 0.000215832664612608, 0.000176967454029842, 0.000068505127616973, -0.000069424742902682, -0.000184190355011937, -0.000230713271907005, -0.000189138296207155, -0.000073204749672537, 0.000074175427903650, 0.000196762257208393, 0.000246420134813116, 0.000201981408164322, 0.000078162625650763, -0.000079185849317590, -0.000210018073450362, -0.000262977244457064, -0.000215516369584254, -0.000083386300671335, 0.000084463619873563, 0.000223977914497400, 0.000280409686313082, 0.000229763662365059, 0.000088883671040780, -0.000090016710189497, -0.000238662845969831, -0.000298743748689948, -0.000244744760136246, -0.000094663019127133, 0.000095853484344265, 0.000254094983343797, 0.000318007042508578, 0.000260482227109979, 0.000100733051878818, -0.000101982739174499, -0.000270297596913621, -0.000338228633673851, -0.000276999827348720, -0.000107102943411236, 0.000108413747730576, 0.000287295227888854, 0.000359439189521313, 0.000294322645678358, 0.000113782382143061, -0.000115156307386361, -0.000305113816954842, -0.000381671141024781, -0.000312477221647216, -0.000120781623031322, 0.000122220793166616, 0.000323780846812693, 0.000404958862688991, 0.000331491698129679, 0.000128111545532420, -0.000129618216936282, -0.000343325500431536, -0.000429338872328245, -0.000351395986404001, -0.000135783718007422, 0.000137360293189765, 0.000363778836999332, 0.000454850053254518, 0.000372221949803186, 0.000143810469395752, -0.000145459512287808, -0.000385173987853600, -0.000481533901775313, -0.000394003608352080, -0.000152204969105368, 0.000153929222117136, 0.000407546375019579, 0.000509434803343028, 0.000416777367172958, 0.000160981316213359, -0.000162783719298887, -0.000430933955389563, -0.000538600341216234, -0.000440582271875112, -0.000170154639241377, 0.000172038351248018, 0.000455377494055271, 0.000569081642104403, 0.000465460294655054, 0.000179741207972757, -0.000181709630594932, -0.000480920870870304, -0.000600933763989898, -0.000491456655438599, -0.000189758559016642, 0.000191815363727754, 0.000507611424989218, 0.000634216132177421, 0.000518620183112941, 0.000200225637107904, -0.000202374795506811, -0.000535500342925207, -0.000668993030639741, -0.000547003722750410, -0.000211162954469824, 0.000213408772553148, 0.000564643096618092, 0.000705334156944460, 0.000576664595745458, 0.000222592770969787, -0.000224939927931539, -0.000595099939139960, -0.000743315250502933, -0.000607665121008003, -0.000234539298282421, 0.000236992890550222, 0.000626936467031057, 0.000783018805633558, 0.000640073206827297, 0.000247028931858366, -0.000249594523206036, -0.000660224259904730, -0.000824534883044994, -0.000673963024796244, -0.000260090515200752, 0.000262774193935144, 0.000695041609952959, 0.000867962035905814, 0.000709415779340179, 0.000273755641808021, -0.000276564086219949, -0.000731474356407665, -0.000913408369783555, -0.000746520589017989, -0.000288059001184119, 0.000290999554688580, 0.000769616842972288, 0.000960992759545087, 0.000785375498972645, 0.000303038776593989, -0.000306119534273251, -0.000809573019867814, -0.001010846250987155, -0.000826088647852655, -0.000318737103814115, 0.000321967012432791, 0.000851457716612444, 0.001063113680736286, 0.000868779617397990, 0.000335200602069044, -0.000338589576072340, -0.000895398117196282, -0.001117955555112437, -0.000913580998930320, -0.000352480990758737, 0.000356040047314153, 0.000941535476214608, 0.001175550237570374, 0.000960640218534190, 0.000370635808596557, -0.000374377225429685, -0.000990027123164971, -0.001236096505513757, -0.001010121672185793, -0.000389729255565358, 0.000393666756208732, 0.001041048812997103, 0.001299816551374660, 0.001062209234041503, 0.000409833182887544, -0.000413982155064632, -0.001094797494794337, -0.001366959520736658, -0.001117109216284518, -0.000431028262294254, 0.000435406016568083, 0.001151494588050966, 0.001437805703117822, 0.001175053878346383, 0.000453405373676507, -0.000458031451301878, -0.001211389878587973, -0.001512671520393546, -0.001236305608321435, -0.000477067260254074, 0.000481963801515613, 0.001274766175347320, 0.001591915495867437, 0.001301161931820560, 0.000502130513458200, -0.000507322700833660, -0.001341944907349678, -0.001675945436628640, -0.001369961545898649, -0.000528727966822535, 0.000534244561333183, 0.001413292890076572, 0.001765227127137015, 0.001443091631560211, 0.000557011600752531, -0.000562885595199052, -0.001489230556750800, -0.001860294918652455, -0.001520996772635027, -0.000587156090115388, 0.000593425510046459, 0.001570242038522082, 0.001961764715236439, 0.001604189908525117, 0.000619363167036008, -0.000626072059964152, -0.001656887597100539, -0.002070350014146387, -0.001693265883504112, -0.000653867026227577, 0.000661066692823469, 0.001749819076472937, 0.002186881873243357, 0.001788918340495664, 0.000690941075648542, -0.000698691614915088, -0.001849799265361891, -0.002312333975097566, -0.001891960964058186, -0.000730906440140022, 0.000739278706138054, 0.001957726376331704, 0.002447854373365730, 0.002003354437744219, 0.000774142773266551, -0.000783220877220927, -0.002074665292018127, -0.002594806096997164, -0.002124240993744322, -0.000821102143093690, 0.000830986686860475, 0.002201887866827212, 0.002754819636825501, 0.002255989172789467, 0.000872327062407373, -0.000883139365460895, -0.002340925501726760, -0.002929861579948975, -0.002400252497459045, -0.000928474182258142, 0.000940361877526701, 0.002493638586280231, 0.003122325501803323, 0.002559047380904841, 0.000990345839045118, -0.001003490384171813, -0.002662309478526009, -0.003335154018933000, -0.002734858054049689, -0.001058932670016911, 0.001073559585060750, 0.002849768888806563, 0.003572005222078269, 0.002930780114227790, 0.001135472109521465, -0.001151865169698162, -0.003059570560968377, -0.003837483532227397, -0.003150720365146793, -0.001221530127919131, 0.001240051415991585, 0.003296237249619821, 0.004137466080300076, 0.003399680503303173, 0.001319117752045373, -0.001340236600159522, -0.003565614422027569, -0.004479574141156610, -0.003684168780499842, -0.001430860952760812, 0.001455196735743292, 0.003875391060372703, 0.004873870852276188, 0.004012812474330403, 0.001560254773084509, -0.001588641952936964, -0.004235887538875806, -0.005333922955517396, -0.004397295560879040, -0.001712054821578439, 0.001745645011990739, 0.004661285297600249, 0.005878469243932371, 0.004853842600783435, 0.001892901334595227, -0.001933329520209755, -0.005171617135210397, -0.006534142759377565, -0.005405659966927490, -0.002112354706489029, 0.002162022113774646, 0.005796130112874725, 0.007340114535605468, 0.006087141810247319, 0.002384698077358510, -0.002447279712426613, -0.006579268897553698, -0.008356452329193131, -0.006951532978202527, -0.002732263232197270, 0.002813679602066593, 0.007592017317084594, 0.009680195094341117, 0.008085889944350300, 0.003192027873692368, -0.003302463835982850, -0.008955178387081751, -0.011478963239091557, -0.009642978631524293, -0.003829974389330461, 0.003988544124142105, 0.010892373512265192, 0.014069382545058302, 0.011917680815787715, 0.004776461444518964, -0.005023668086517925, -0.013868986327250924, -0.018129949077564683, -0.015562321252089433, -0.006330056718488720, 0.006768894990502300, 0.019039870612324598, 0.025424769859174790, 0.022363717717977984, 0.009358034592196309, -0.010345415913702690, -0.030277203769263107, -0.042422266202238990, -0.039606615841646840, -0.017881406664502306, 0.021857508307246122, 0.073579941457370346, 0.127338316926133649, 0.171705820348038662, 0.196761783075238006, 0.196761783075238006, 0.171705820348038662, 0.127338316926133649, 0.073579941457370346, 0.021857508307246122, -0.017881406664502306, -0.039606615841646840, -0.042422266202238990, -0.030277203769263107, -0.010345415913702690, 0.009358034592196309, 0.022363717717977984, 0.025424769859174790, 0.019039870612324598, 0.006768894990502300, -0.006330056718488720, -0.015562321252089433, -0.018129949077564683, -0.013868986327250924, -0.005023668086517925, 0.004776461444518964, 0.011917680815787715, 0.014069382545058302, 0.010892373512265192, 0.003988544124142105, -0.003829974389330461, -0.009642978631524293, -0.011478963239091557, -0.008955178387081751, -0.003302463835982850, 0.003192027873692368, 0.008085889944350300, 0.009680195094341117, 0.007592017317084594, 0.002813679602066593, -0.002732263232197270, -0.006951532978202527, -0.008356452329193131, -0.006579268897553698, -0.002447279712426613, 0.002384698077358510, 0.006087141810247319, 0.007340114535605468, 0.005796130112874725, 0.002162022113774646, -0.002112354706489029, -0.005405659966927490, -0.006534142759377565, -0.005171617135210397, -0.001933329520209755, 0.001892901334595227, 0.004853842600783435, 0.005878469243932371, 0.004661285297600249, 0.001745645011990739, -0.001712054821578439, -0.004397295560879040, -0.005333922955517396, -0.004235887538875806, -0.001588641952936964, 0.001560254773084509, 0.004012812474330403, 0.004873870852276188, 0.003875391060372703, 0.001455196735743292, -0.001430860952760812, -0.003684168780499842, -0.004479574141156610, -0.003565614422027569, -0.001340236600159522, 0.001319117752045373, 0.003399680503303173, 0.004137466080300076, 0.003296237249619821, 0.001240051415991585, -0.001221530127919131, -0.003150720365146793, -0.003837483532227397, -0.003059570560968377, -0.001151865169698162, 0.001135472109521465, 0.002930780114227790, 0.003572005222078269, 0.002849768888806563, 0.001073559585060750, -0.001058932670016911, -0.002734858054049689, -0.003335154018933000, -0.002662309478526009, -0.001003490384171813, 0.000990345839045118, 0.002559047380904841, 0.003122325501803323, 0.002493638586280231, 0.000940361877526701, -0.000928474182258142, -0.002400252497459045, -0.002929861579948975, -0.002340925501726760, -0.000883139365460895, 0.000872327062407373, 0.002255989172789467, 0.002754819636825501, 0.002201887866827212, 0.000830986686860475, -0.000821102143093690, -0.002124240993744322, -0.002594806096997164, -0.002074665292018127, -0.000783220877220927, 0.000774142773266551, 0.002003354437744219, 0.002447854373365730, 0.001957726376331704, 0.000739278706138054, -0.000730906440140022, -0.001891960964058186, -0.002312333975097566, -0.001849799265361891, -0.000698691614915088, 0.000690941075648542, 0.001788918340495664, 0.002186881873243357, 0.001749819076472937, 0.000661066692823469, -0.000653867026227577, -0.001693265883504112, -0.002070350014146387, -0.001656887597100539, -0.000626072059964152, 0.000619363167036008, 0.001604189908525117, 0.001961764715236439, 0.001570242038522082, 0.000593425510046459, -0.000587156090115388, -0.001520996772635027, -0.001860294918652455, -0.001489230556750800, -0.000562885595199052, 0.000557011600752531, 0.001443091631560211, 0.001765227127137015, 0.001413292890076572, 0.000534244561333183, -0.000528727966822535, -0.001369961545898649, -0.001675945436628640, -0.001341944907349678, -0.000507322700833660, 0.000502130513458200, 0.001301161931820560, 0.001591915495867437, 0.001274766175347320, 0.000481963801515613, -0.000477067260254074, -0.001236305608321435, -0.001512671520393546, -0.001211389878587973, -0.000458031451301878, 0.000453405373676507, 0.001175053878346383, 0.001437805703117822, 0.001151494588050966, 0.000435406016568083, -0.000431028262294254, -0.001117109216284518, -0.001366959520736658, -0.001094797494794337, -0.000413982155064632, 0.000409833182887544, 0.001062209234041503, 0.001299816551374660, 0.001041048812997103, 0.000393666756208732, -0.000389729255565358, -0.001010121672185793, -0.001236096505513757, -0.000990027123164971, -0.000374377225429685, 0.000370635808596557, 0.000960640218534190, 0.001175550237570374, 0.000941535476214608, 0.000356040047314153, -0.000352480990758737, -0.000913580998930320, -0.001117955555112437, -0.000895398117196282, -0.000338589576072340, 0.000335200602069044, 0.000868779617397990, 0.001063113680736286, 0.000851457716612444, 0.000321967012432791, -0.000318737103814115, -0.000826088647852655, -0.001010846250987155, -0.000809573019867814, -0.000306119534273251, 0.000303038776593989, 0.000785375498972645, 0.000960992759545087, 0.000769616842972288, 0.000290999554688580, -0.000288059001184119, -0.000746520589017989, -0.000913408369783555, -0.000731474356407665, -0.000276564086219949, 0.000273755641808021, 0.000709415779340179, 0.000867962035905814, 0.000695041609952959, 0.000262774193935144, -0.000260090515200752, -0.000673963024796244, -0.000824534883044994, -0.000660224259904730, -0.000249594523206036, 0.000247028931858366, 0.000640073206827297, 0.000783018805633558, 0.000626936467031057, 0.000236992890550222, -0.000234539298282421, -0.000607665121008003, -0.000743315250502933, -0.000595099939139960, -0.000224939927931539, 0.000222592770969787, 0.000576664595745458, 0.000705334156944460, 0.000564643096618092, 0.000213408772553148, -0.000211162954469824, -0.000547003722750410, -0.000668993030639741, -0.000535500342925207, -0.000202374795506811, 0.000200225637107904, 0.000518620183112941, 0.000634216132177421, 0.000507611424989218, 0.000191815363727754, -0.000189758559016642, -0.000491456655438599, -0.000600933763989898, -0.000480920870870304, -0.000181709630594932, 0.000179741207972757, 0.000465460294655054, 0.000569081642104403, 0.000455377494055271, 0.000172038351248018, -0.000170154639241377, -0.000440582271875112, -0.000538600341216234, -0.000430933955389563, -0.000162783719298887, 0.000160981316213359, 0.000416777367172958, 0.000509434803343028, 0.000407546375019579, 0.000153929222117136, -0.000152204969105368, -0.000394003608352080, -0.000481533901775313, -0.000385173987853600, -0.000145459512287808, 0.000143810469395752, 0.000372221949803186, 0.000454850053254518, 0.000363778836999332, 0.000137360293189765, -0.000135783718007422, -0.000351395986404001, -0.000429338872328245, -0.000343325500431536, -0.000129618216936282, 0.000128111545532420, 0.000331491698129679, 0.000404958862688991, 0.000323780846812693, 0.000122220793166616, -0.000120781623031322, -0.000312477221647216, -0.000381671141024781, -0.000305113816954842, -0.000115156307386361, 0.000113782382143061, 0.000294322645678358, 0.000359439189521313, 0.000287295227888854, 0.000108413747730576, -0.000107102943411236, -0.000276999827348720, -0.000338228633673851, -0.000270297596913621, -0.000101982739174499, 0.000100733051878818, 0.000260482227109979, 0.000318007042508578, 0.000254094983343797, 0.000095853484344265, -0.000094663019127133, -0.000244744760136246, -0.000298743748689948, -0.000238662845969831, -0.000090016710189497, 0.000088883671040780, 0.000229763662365059, 0.000280409686313082, 0.000223977914497400, 0.000084463619873563, -0.000083386300671335, -0.000215516369584254, -0.000262977244457064, -0.000210018073450362, -0.000079185849317590, 0.000078162625650763, 0.000201981408164322, 0.000246420134813116, 0.000196762257208393, 0.000074175427903650, -0.000073204749672537, -0.000189138296207155, -0.000230713271907005, -0.000184190355011937, -0.000069424742902682, 0.000068505127616973, 0.000176967454029842, 0.000215832664612608, 0.000172283124906551, 0.000064926507244072, -0.000064056533947356, -0.000165450123030260, -0.000201755317807412, -0.000161022115719702, -0.000060673730289170, 0.000059852034047139, 0.000154568292092430, 0.000188459143154331, 0.000150389596268351, 0.000056659691309778, -0.000055884958206672, -0.000144304630786221, -0.000175922878110533, -0.000140368491086957, -0.000052877915406734, 0.000052148878000716, 0.000134642428700383, 0.000164126012365372, 0.000130942322045582, 0.000049322151633496, -0.000048637584827121, -0.000125565540321545, -0.000153048720998143, -0.000122095155297502, -0.000045986353115494, 0.000045345070402292, 0.000117058334936164, 0.000142671803724017, 0.000113811553056839, 0.000042864658978746, -0.000042265509031110, -0.000109105651089117, -0.000132976629664550, -0.000106076529760534, -0.000039951377921370, 0.000039393241488579, 0.000101692755182138, 0.000123945087139036, 0.000098875512216028, 0.000037240973278969, -0.000036722760367577, -0.000094805303839106, -0.000115559538025647, -0.000092194303377636, -0.000034728049450568, 0.000034248696762069, 0.000088429309703752, 0.000107802776287760, 0.000086019049431325, 0.000032407339565279, -0.000031965808168663, -0.000082551110369302, -0.000100657990301960, -0.000080336209899882, -0.000030273694282020, 0.000029868967500983, 0.000077157340169789, 0.000094108728660510, 0.000075132530509312, 0.000028322071625328, -0.000027953153121900, -0.000072234904589436, -0.000088138869153311, -0.000070395018582609, -0.000026547527769762, 0.000026213439807925, 0.000067770957070145, 0.000082732590662958, 0.000066110920749712, 0.000024945208693802, -0.000024644990568200, -0.000063752878018231, -0.000077874347731920, -0.000062267702782540, -0.000023510342631729, 0.000023243049247959, 0.000060168255830309, 0.000073548847583519, 0.000058853031381882, 0.000022238233258526, -0.000022002933852834, -0.000057004869774847, -0.000069741029398566, -0.000055854757758885, -0.000021124253548985, 0.000020920030536147, 0.000054250674580962, 0.000066436045667542, 0.000053260902868175, 0.000020163840257280, -0.000019989788196632, -0.000051893786599226, -0.000063619245454336, -0.000051059644162361, -0.000019352488968303, 0.000019207713638604, 0.000049922471411311, 0.000061276159422002, 0.000049239303749143, 0.000018685749676130, -0.000018569367250878, -0.000048325132775929, -0.000059392486483909, -0.000047788337842442, -0.000018159222848913, 0.000018070359164356, 0.000047090302808154, 0.000057954081955340, 0.000046695327408244, 0.000017768555942912, -0.000017706345851678, -0.000046206633297888, -0.000056946947090992, -0.000045948969914073, -0.000017509440331449]'
    comment: FIR Orden900 Hamming Fc=1000Hz Fs=10kHz
    num_muestras_log: '80000000'
    num_nodos: '3'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_1, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', customModule_filtro_FIR_cluster_log_0_2, '0']
- [customModule_filtro_FIR_cluster_log_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_1, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_2, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_log_0_3_0_0_0_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
