options:
  parameters:
    generate_options: qt_gui
    id: pruebas_filtro_cluster
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '8000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: customModule_filtro_FIR_cluster_0
  id: customModule_filtro_FIR_cluster
  parameters:
    coef: |-
      [-0.005230107296619057773157113189199662884,-0.012931101513474829028949031339834618848,
       0.01705008032939041642817024069245235296, 0.163563548040774831004995348848751746118,
       0.337547580439928718298858711932552978396, 0.337547580439928718298858711932552978396,
       0.163563548040774831004995348848751746118, 0.01705008032939041642817024069245235296, 
      -0.012931101513474829028949031339834618848,-0.005230107296619057773157113189199662884]
    num_nodo: '1'
  states: {}
- name: customModule_filtro_FIR_cluster_0_0
  id: customModule_filtro_FIR_cluster
  parameters:
    coef: '[-0.002649625683986659048507750213730105315,-0.00102626916841334447742795088487355315,  0.005786026774656596351198434291518424288, 0.01277825509292213751466604776396707166, -0.000353022399592585510788578240237711725,-0.03747830192258361226009810707182623446, -0.049545607147856732255242206974799046293, 0.031297171753709024377698710850381758064, 0.199005919118201618500663130362227093428, 0.342185453582943499561963562882738187909, 0.342185453582943499561963562882738187909, 0.199005919118201618500663130362227093428, 0.031297171753709024377698710850381758064,-0.049545607147856732255242206974799046293,-0.03747830192258361226009810707182623446, -0.000353022399592585510788578240237711725,0.01277825509292213751466604776396707166, 0.005786026774656596351198434291518424288,-0.00102626916841334447742795088487355315, -0.002649625683986659048507750213730105315]'
    num_nodo: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_0, '0']
- [analog_noise_source_x_0, '0', customModule_filtro_FIR_cluster_0_0, '0']
- [analog_sig_source_x_0, '0', customModule_filtro_FIR_cluster_0, '0']
- [analog_sig_source_x_0, '0', customModule_filtro_FIR_cluster_0_0, '0']
- [customModule_filtro_FIR_cluster_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_0, '0', qtgui_time_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_0_0, '0', qtgui_freq_sink_x_0, '0']
- [customModule_filtro_FIR_cluster_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
